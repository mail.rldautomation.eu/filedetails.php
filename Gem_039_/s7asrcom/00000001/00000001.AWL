
//_____________________________________________________________________________________________
//
//	SINAUT Software
//
//	(c) SIEMENS AG, 2000
//	ATD OGMT
//
//	All Rights Reserved.
//_____________________________________________________________________________________________
//
//	SINAUT TD7 Basic01 (english mnemonic)
//	Part of the SINAUT Software Package 6NH7997-0CA15-0AA0
//
//	Version 2.1
//	30. 10. 2001
//
//	STEP7 Software for the SINAUT ST7 System
//_____________________________________________________________________________________________
//
//_____________________________________________________________________________________________
//
//  Start SINAUT TD7 UserSource
//  generated by SINAUT configuration - version V3.0
//           on 10/13/04 11:32:22.
//  Station:   SIMATIC 300(1)
//  CPU:       CPU 316-2 DP
//_____________________________________________________________________________________________

TYPE "SubscriberObject"


  STRUCT
   SubscriberNo : INT ;	//subscriber number
   CurrentConnectDescrAddr : WORD ;	//address of current connection description
   NofCurrentConnectDescr : INT ;	//serial no. of current connection description
   SubscriberType : BYTE ;
   ReceiveTimeStamp : BOOL  := TRUE;	//subscriber object has time stamp buffer
   SpareFlag1_1 : BOOL ;	//
   SpareFlag1_2 : BOOL ;	//
   SpareFlag1_3 : BOOL ;	//
   SpareFlag1_4 : BOOL ;	//
   SpareFlag1_5 : BOOL ;	//
   SpareFlag1_6 : BOOL ;	//
   RemoteSubscriber : BOOL ;	//destination subscriber is remote (false = local)
   SupervisionTime : INT  := 900;	//default value for monitoring time of a request (s)
   RemainingReqMonTime : INT ;	//remaining request monitoring time (in milli seconds)
   SubscriberNoOfLocalTIM : INT ;	//subscriber number of the local TIM
   RemainingConnectTime : INT ;	//remaining connection time of a permanent call
   NoOfReceivedBytes : BYTE ;	//no. of received bytes
   SpareByte1 : BYTE ;
   ReceiveMessageHeaderF3F4 : WORD ;	//F3 and F4 information of received message header
   SourceSubscriberNo : INT ;	//source subscriber number of received message
   SourceObjectNo : INT ;	//source object number of received message
   StartIndexNo : INT ;	//start index number of received message
   TimeDT_1 : DWORD ;	//year, month, day and hour
   TimeDT_2 : DWORD ;	//minute, second, milli second and time status flags
   ReceiveIndex0 : WORD ;	//receive index 0, puls bits
   ReceiveIndex2 : WORD ;	//receive index 0, puls bits
   ReceiveIndex4 : WORD ;	//receive index 4, connection bits
   ReceiveIndex6 : WORD ;	//receive index 6, connection bits
   ReceiveIndex8 : WORD ;	//receive index 8, status bits
   ReceiveIndex10 : WORD ;	//receive index 10, status bits
   ReceiveIndex12 : WORD ;	//receive index 12, status bits
   SendIndex0 : WORD ;	//send index 0, pulse bits
   SendIndex2 : WORD ;	//send index 0, pulse bits
   SendIndex4 : WORD ;	//send index 4, connection bits
   SendIndex6 : WORD ;	//send index 6, connection bits
   SendIndex8 : WORD ;	//send index 8, status bits
   SendIndex10 : WORD ;	//send index 10, status bits
   SendIndex12 : WORD ;	//send index 12, status bits
  END_STRUCT ;
END_TYPE

//_____________________________________________________________________________________________

TYPE "ConnectionDescription"


  STRUCT
   CommunicationDBNo : INT ;	//DB no. of communication DB
   Spare : BYTE ;	//spare byte
   ConnectionType : BYTE ;	//the structure of communication DB is for X communication
   ConnectIDofLocalPartner : INT ;	//MPI no. or CFB-ID of the local connected partner
   SubscrNoOfLocalPartner : INT ;	//subscriber No. of the local connected partner
   SubscrAddrOfLocalPartner : WORD ;	//address of the local connected subscriber object
   NofAlternatConnectDescr : INT ;	//no. of the alternative connection description (redundancy)
   AlternatConnectDescrAddr : WORD ;	//address of the alternative connection description (redundancy)
  END_STRUCT ;
END_TYPE

//_____________________________________________________________________________________________

DATA_BLOCK "BasicData"
TITLE =
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : BasicDat
VERSION : 1.1


  STRUCT
   CurrentDate : DWORD ;	//current year, month, day and hour
   CurrentTime : DWORD ;	//current minute, second, milli second and status
   LastSyncDate : DWORD ;	//year, month, day, hour of last synchronisation
   LastSyncTime : DWORD ;	//mintue, second, milli second and status of last synchronisation
   TimeProcessingActive : BOOL ;	//time processing of CPU is activated (only when FC TimeTask is running)
   CpuClockOk : BOOL ;	//CPU clock is ok
   TimClockOk : BOOL ;	//TIM clock is ok
   DaylightSavingActive : BOOL ;	//daylight saving time (changing of summer time)
   TimeFlag1_4 : BOOL ;	//time management flag
   TimeFlag1_5 : BOOL ;	//time management flag
   Pulse_1sEdgeFlag : BOOL ;	//1 second pulse edge flag
   Pulse_1s : BOOL ;	//second pulse flag; appears 1 OB1-cycle per second
   SpareByte2 : BYTE ;
   LastOB1CycleTime : INT ;	//last OB1 cycle time (ms)
   LastSystemTime : TIME ;	//system time from SFC64 "TIME_TCK"
   OwnSubscrNo : INT ;	//own subscriber number
   OwnMpiNo : DWORD ;	//own MPI number
   StartSystemFlags : WORD  := W#16#3E;	//start address of system flags                    (DW  62)
   StartOrgSendData : WORD  := W#16#5E;	//start address of data for FC Create              (DW  94)
   StartSubscrObjList : WORD  := W#16#7C;	//start address of the subscriber management list  (DW 124)
   SubscrObjectLength : INT  := 62;	//lengh of a subscriber object (fix value)
   NofSubscrObjects : INT ;	//number of subscriber object entrys
   OffsetRcvOrgIndex0 : INT  := 34;	//offset of bytes to the receive organizational index 0 in a subscriber object
   OffsetSendOrgIndex0 : INT  := 48;	//offset of bytes to the send organizational index 0 in a subscriber object
   StartConnectionDescrList : WORD ;	//start of the connection description list
   ConnectionDescrLength : INT  := 14;	//length of a connection description
   NofConnectionDescription : INT ;	//number of connection descriptions
   DB_ObjectList1 : INT ;	//DB number of objectlist 1
   NofObjectItems1 : INT ;	//number of object items of objectlist 1
   DB_ObjectList2 : INT ;	//DB number of objectlist 2
   NofObjectItems2 : INT ;	//number of object items of objectlist 2
   FC_User : INT ;	//number of the user FC
   CurrentComDB : INT ;	//current communication DB
   SystemInitialFlag : BOOL ;	//system initialisation starts when flag changes from false to true
   SystemStart : BOOL ;	//system start
   SystemStartEdgeFlag : BOOL ;	//system start edge flag
   NoSubscrObjectDetected : BOOL ;	//no subscriber objet entry in subscriber object list found
   PLC_TypeSeries400 : BOOL ;	//PLC type is from the 400 series
   ObjectDB_Available : BOOL ;	//flag displays OB121 that FC Distribute requests an SINAUT object DB
   SystemFlag1_6 : BOOL ;
   SystemFlag1_7 : BOOL ;
   GeneralRequest : BOOL ;	//general request of subscriber is running
   DelayGenReqEnd : BOOL ;	//delay of general end message
   CounterValueStorage : BOOL ;	//counter value restorage
   XPDU_ReceiveIsActive : BOOL ;	//a X communication receive function is active
   ParameterError : BOOL ;	//parameter error
   ParameterErrorEdgeFlag : BOOL ;	//parameter error edge flag
   ProcessDataBlocked : BOOL ;	//no process data will be send any longer
   GlobalCmdOutputError : BOOL ;	//Output error in subscriber-receive index detected
   ObjRefListGen : BOOL ;	//request for object reference list generation
   ObjRefListGenActive : BOOL ;	//creating of object reference list(s) is active
   ObjRefListLen : BOOL ;	//calculating of object reference lists is running
   ObjRefListEntry : BOOL ;	//entry in object lists is running
   SortObjRefList1 : BOOL ;	//object reference list 1 will be sorted
   SortObjRefList2 : BOOL ;	//object reference list 2 will be sorted
   ObjRefList1_Avail : BOOL ;	//object reference list 1 available
   ObjRefList2_Avail : BOOL ;	//object reference list 2 available
   ObjRefList1_Error : BOOL ;	//error in object reference list 1
   ObjRefList2_Error : BOOL ;	//error in object reference list 2
   ObjRefList2_Active : BOOL ;	//creating of object reference list 2 is active
   ObjRefList_Delete : BOOL ;	//deleting existing object reference lists (only S7 400)
   ObjRefList_Compress : BOOL ;	//compress PLC memory (only S7 400)
   SystemFlag4_5 : BOOL ;
   SystemFlag4_6 : BOOL ;
   SystemFlag4_7 : BOOL ;
   SystemflagByte5 : BYTE ;
   SystemflagByte6 : BYTE ;
   SystemflagByte7 : BYTE ;
   SystemflagByte8 : BYTE ;
   EventID : WORD ;	//parameter of SFC52: event ID no. for the diagnose message
   Info1 : WORD ;	//parameter of SFC52: additional information 1
   Info2 : DWORD ;	//parameter of SFC52: additional information 2
   RetVal : INT ;	//parameter of SFC52: error code
   HW_Start1ofNCheck : BOOL ;	//request from Cmd-/Set-Typical for 1-of-N check, HW-Inputs
   HW_EntryLocked : BOOL ;	//Entry of HW-Inputs into Send-Buffers locked
   HW_1of8_Error : BOOL ;	//1-of-8 Error in HW-Inputs detected by Cmd-/Setp-Typical
   HW_1ofN_Error : BOOL ;	//1-of-N Error in HW-Inputs detected by FC_Safe
   HW_SendAllowance : BOOL ;	//allowance to enter HW_Cmd-/Setp-Telegram into sendbuffer
   HW_CmdSetpNewReq : BOOL ;	//new transmission request for Cmds or setpoints
   HW_CmdDelayTActive : BOOL ;	//transmission delay for commands (HW-Input) is active
   HW_CmdSupvisTActive : BOOL ;	//supervision time for commands (HW-Input) is active
   HW_CmdInputError : BOOL ;	//Error by HW_Telegramm entry into Send-Buffer
   SW_Start1ofNCheck : BOOL ;	//request from Cmd-/Set-Typical for 1-of-N check, SW-Inputs
   SW_EntryLocked : BOOL ;	//Entry of SW-Inputs into Send-Buffers locked
   SW_1of8_Error : BOOL ;	//1-of-8 Error in SW-Inputs detected by Cmd-/Setp-Typical
   SW_1ofN_Error : BOOL ;	//1-of-N Error in SW-Inputs detected by FC_Safe
   SW_CmdInputError : BOOL ;	//Error by SW_Telegramm entry into Send-Buffer
   CmdOut_1ofNCheckReq : BOOL ;	//Request for 1-if-N-Check in Command Output Typical
   CmdOut_1ofNError : BOOL ;	//1-of-N-Error detected by Command Output Typical
   SW_CmdSetpComDB : INT ;	//communication DB of last SW_command or setpoint entry
   SW_CmdSetpComDB_DBB : WORD ;	//start of SW_command or setpoint message inside the communication DB
   HW_CmdSetpComDB : INT ;	//communication DB of last HW_command or setpoint entry
   HW_CmdSetpComDB_DBB : WORD ;	//start of HW_command or setpoint message inside the communication DB
   CmdDelayTimer : INT ;	//delay timer for HW_command clearance (ms)
   CmdSupvisTimer : INT ;	//supervision timer for HW_command monitoring (ms)
   MaxNofDestSubscr : BYTE ;	//max. no. of destination subscribers
   ParamNofDestSubscr : BYTE ;	//number of destination subscribers (no. of valid subscribers)
   StartIndexInSubscrObject : WORD ;	//start address to index in subscriber object
   NofBytesToTransmit : BYTE ;	//number of bytes to transmit
   ConnectionErrorFlags : BYTE ;	//connection error occured
   SendFlag0 : BOOL ;	//send flag bit 0
   DataLossFlags : BYTE ;	//data loss flags (only bit 0)
   MessageLength : BYTE ;	//no. of bytes of the message
   MessageHeaderFieldF1 : BYTE ;	//F1 field of the Message header
   MessageHeaderFieldF2 : BYTE ;	//F2 field of the Message header
   MessageHeaderFieldF3 : BYTE ;	//F3 field of the Message header
   MessageHeaderFieldF4 : BYTE ;	//F4 field of the Message header
   NofDestSubscrInMessage : BYTE ;	//no. of destination subscr. in the message / length of subscr. no. in words
   DestinationSubscrNo : INT ;	//destination subscriber number (= current subscriber object)
   DestinationObjectNo : INT ;	//destination object number =7FFF (or 7FF2 or 7FF3 possible if TIM)
   SourceObjectNo : INT ;	//source object number = 7FFF
   StartIndexNo : INT ;	//(=0, 2 or 8)
   YearMonthDayHour : DWORD ;	//year, month, day, hour
   MinSecMillisecStatus : DWORD ;	//minute, second, milli seconds and status flags of time
   SubscriberObject : ARRAY  [ 1 .. 2 ] OF //list of subscriber objects
   "SubscriberObject";
   ConnectionDescription : ARRAY  [ 1 .. 1 ] OF //list of connection descriptions
   "ConnectionDescription";
   SinautKeyWord : ARRAY  [1 .. 4 ] OF CHAR  := 'S', 'T', ' ', '7';	//This keyword allows SINAUT tasks running.
//If it is not available, system stop
  END_STRUCT ;
BEGIN
		OwnSubscrNo := 39;
		OwnMpiNo := DW#16#2;
		NofSubscrObjects := 2;
		NofConnectionDescription := 1;
		PLC_TypeSeries400 := FALSE;
		SubscriberObject[1].SubscriberNo := 1;
		SubscriberObject[1].NofCurrentConnectDescr := 1;
		SubscriberObject[1].SubscriberType := B#16#2;
		SubscriberObject[1].RemoteSubscriber := TRUE;
		SubscriberObject[2].SubscriberNo := 1001;
		SubscriberObject[2].NofCurrentConnectDescr := 1;
		SubscriberObject[2].SubscriberType := B#16#1;
		SubscriberObject[2].RemoteSubscriber := FALSE;
		ConnectionDescription[1].CommunicationDBNo := 511;
		ConnectionDescription[1].ConnectionType := B#16#2;
		ConnectionDescription[1].ConnectIDofLocalPartner := 3;
		ConnectionDescription[1].SubscrNoOfLocalPartner := 1001;
		ConnectionDescription[1].NofAlternatConnectDescr := 0;

END_DATA_BLOCK

//_____________________________________________________________________________________________

FUNCTION "Startup" : VOID
TITLE = Startup
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : Startup
VERSION : 1.0

BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!
RUN:  NOP   0;
NETWORK
TITLE = SNAUT ST7 system start

      SET   ;
      S     "BasicData".SystemStart;
      R     "BasicData".SystemStartEdgeFlag;

END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION "Search" : DWORD
TITLE =	Search
//
//
//	This FC is searching for one data record in an array of records (DB). Before calling this FC the DB should
//	be already open.
//	The array of records must be rised up sorted depending on the parameters "CodeWanted" and "CodeMask".
//
//	Output parameter description:
//	The low word of RET_VAL displays the address of the required data record, but only when the value of the high
//	word is 0.
//	When an error occured or the requested data record could not be found, the highest bit in high word is 1 and
//	the other bits (the 15 lower bits) are displaying an error code. The delivered address of the low word is not
//	valid then.
//
//	Input parameter description:
//	"CompareValue"	:	wanted value (1 bit up to 4 bytes, depending on parameter "ValueMask")
//	"ValueMask"		:	the relevant flags to compare can be configured by this mask,
//					(i.ex.: if all 4 bytes are wanted, input to ValueMask is D#16# FF FF FF FF.
//	"NofObjects"		:	number of data records of array in the DB
//	"ObjectLength"	:	length of a data record in byte
//	"StartAddress"	:	address of the first data record in the list (range 0 .. 64k)
//
//	Error code (high word) of RET_VAL
//	(HEX)	B101:	 	wanted record not founded
//	(HEX)	B102:		wanted code =0
//	(HEX)	B103:		codemask =0
//	(HEX)	B104:		no. of objects <=0
//	(HEX)	B105:		object length <=0
//
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : Search
VERSION : 1.0


VAR_INPUT
  NofObjects : INT ;	//no. of objects
  ObjectLength : INT ;	//all objects in the requiered list must have the same length!!
  StartAddress : WORD ;	//start of the list in the DB
  CodeWanted : DWORD ;	//search for this code
  CodeMask : DWORD ;	//founded code can be filtered by this mask
END_VAR
VAR_TEMP
  Length : INT ;	//length of a data record
  Start : DINT ;	//address of the beginning of the data records
  End : DINT ;	//address the end of the data records (last DW address*1)
  CompareAddress : DINT ;	//address of current data record
  TempBuffer : DINT ;	//pointer of current data record
END_VAR
BEGIN
NETWORK
TITLE =input check

      L     #CodeWanted; //IF wanted code = 0
      L     0;
      T     #CompareAddress;
      ==D   ;
      L     2; //THEN wanted code not permissible
      JC    No; //error 2

      L     #CodeMask; //IF codemask = 0
      L     L#0;
      ==D   ;
      L     3; //THEN codemask is not permissible
      JC    No; //error 3

      L     #NofObjects; //IF no. of objects = 0
      L     0;
      <=I   ;
      L     4; //THEN no. of objects are not permissible
      JC    No; //error 4

      L     #ObjectLength; //IF object length is <= 0
      L     0;
      <=I   ;
      L     5; //THEN object length is not permissible
      JC    No; //error 5

NETWORK
TITLE =calculating the start and end (address) of the record field

      L     #NofObjects;
      L     #ObjectLength; //length of a object
      T     #Length;
      *D    ;
      L     #StartAddress; //start address of data records
      T     #Start;
      +D    ;
      T     #End; //end address of data records + 1

NETWORK
TITLE =binary search routine:
//searching for address of wanted data record
//
//calculate new address of the middle data record
Loop: NOP   0;
      L     #End; //end address
      L     #Start; //start address
      -D    ;
      SRD   1;
      L     #Length; //length of data record
      /D    ;
      L     #Length; //middle=((end point-start point)/2)DIV length
      *D    ;
      L     #Start;
      +D    ; //new address

//Compare new address and old address, because if equal searching ends

      L     #CompareAddress; //old address or preset
      ==D   ; //IF old address = new address
      TAK   ;
      L     1; //THEN data record not found
      JC    No;

      TAK   ; //ELSE
      SLD   3; //middle addr:=start+middle*length
      T     #CompareAddress; //middle addr:=start+middle*length (pointer)

//compare founded code with code wanted

      L     DBD [#CompareAddress];
      L     #CodeMask; //compare only required flags
      AD    ;
      T     #TempBuffer; //store result 1 temporary
      L     #CodeWanted;
      L     #CodeMask; //compare only required flags
      AD    ;
      L     #TempBuffer; //restore result 1
      ==D   ; //IF founded code = wanted code
      JC    Yes; //THEN address founded

//fitting the remaining area for next search

      >D    ; //IF founded code > wanted code
      L     #CompareAddress;
      SRD   3;
      T     #CompareAddress;
      JC    Csta; //THEN change start address
      T     #End; //ELSE change end address
      JU    Loop;

Csta: T     #Start; //change start address
      JU    Loop;
//END LOOP

NETWORK
TITLE =
//data record founded
Yes:  L     #CompareAddress;
      SRD   3;
      T     #RET_VAL; //return of the data record address, high word is 0


      BEU   ;
NETWORK
TITLE =data record not founded or failure occured

No:   L     W#16#B100;
      +I    ;
      SLD   16;
      T     #RET_VAL; //return of the error code, low word is 0

END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION "Diagnose" : VOID
TITLE =    Diagnose
//
//
//
//
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : Diagnose
VERSION : 1.0


VAR_TEMP
  SaveAR1 : DWORD ;	//temp buffer of address pointer 1
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      TAR1  #SaveAR1;
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;

      CALL "STP" ;//Stop CPU !!!
RUN:  LAR1  #SaveAR1;

NETWORK
TITLE =  send diagnose message

      CALL "WR_USMSG" (
           SEND                     := TRUE,
           EVENTN                   := "BasicData".EventID,
           INFO1                    := "BasicData".Info1,
           INFO2                    := "BasicData".Info2,
           RET_VAL                  := "BasicData".RetVal);

END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION "Distribute" : VOID
TITLE =	Distrib
//
//	This FC distributs messages to the data objects and subscriber objects
//	which are entered as receive block into the receive buffer of communication DB
//
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : Distrib
VERSION : 1.3


VAR_TEMP
  AddressFirstData : DWORD ;	//pointer to start of first data byte
  AddressStartIndexNo : DWORD ;	//pointer to start of index no.
  OrgIndex0 : DWORD ;	//pointer to organisational index 0 of data object
  RCV_BufferPointer : DWORD ;	//receive buffer pointer
  TempBuffer : DWORD ;	//temporary buffer
  FoundedAddress : DWORD ;	//return of FC "Search"
  NofRCV_Bytes : INT ;	//no. of received bytes in data block
  OrgSegmentLength : INT ;	//organisation segment length
  RCV_BufferLength : INT ;	//length of receive buffer
  StartIndexNo : INT ;	//start index no.
  StartSubscriberRcvBlock : INT ;	//start of the subscriber object receive block
  StartSubscriberSendBlock : INT ;	//start of the subscriber object send block
  TempBlockNo : INT ;	//temporary DI / DB / FC no.
  XComData : INT ;	//current communication buffer
  TempIntegerBuffer : INT ;	//temporary buffer for common use
  MessageLength : BYTE ;	//length of received message (in bytes)
  NofDestSubscr : BYTE ;	//no. of destination subscribers
  NofRCV_ClearData : BYTE ;	//no. of received clear data bytes
  NofRCV_OrgIndexBytes : BYTE ;	//no. of received organisation index bytes
  RCV_MessageExists : BOOL ;	//receive message is existing ((EV)
  RCV_BuffContentsFault : BOOL ;	//contens of receive buffer is faulty (EF)
  RCV_FunctionStartUp : BOOL ;	//starts up the receive function (EA)
  RCV_NilRuns : BOOL ;	//receive NIL function is running (NIL)
  ProcessObjectBlocked : BOOL ;	//process object is in access (PO)
  SubscriberObjectBlocked : BOOL ;	//subscriber object is in access (TO)
  SpareBit7 : BOOL ;
  SpareBit8 : BOOL ;
  SpaceForSendMessExists : BOOL ;	//flag (SZ) in object data block
  SpaceForAddressExists : BOOL ;	//flag (EA) in object data block
  SpaceForTimeStampExists : BOOL ;	//flag (EZ) in object data block
  MessageTimeStampExists : BOOL ;	//message has a time stamp
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!

RUN:  NOP   0;
NETWORK
TITLE =load current data of DB XComData

      L     "BasicData".CurrentComDB;
      T     #XComData;
      OPN   DI [#XComData]; //open current DB XComData

      L     DIW    6; //start address of receive buffer "no. of received bytes"
      SLD   3;
      T     #RCV_BufferPointer; //pointer to element "no. of received bytes" (X_RCV: RET_VAL)

      L     DIW    8; //length of receive buffer
      T     #RCV_BufferLength;

      L     DIB   16; //load RCV_BufferFlags
      LAR1  P##RCV_MessageExists; //start address of local flag bits
      T     LB [AR1,P#0.0]; //restore local flag bits

NETWORK
TITLE =check contents of the receive buffer

      A     #RCV_MessageExists; //IF (old) receive data existing
      JC    P1; //THEN continue at point 1

      L     DIW    6; //ELSE	reset current start address of first message
      T     DIW   10;
      L     DIW   14;
      T     #NofRCV_Bytes; //RET_VAL (of SFC X_RCV) = length of received data record
      L     #RCV_BufferLength;
      >I    ; //IF no. of received bytes > receive buffer length
      JCN   Chck;

      =     #RCV_BuffContentsFault; //receive buffer contents fault occured
      L     W#16#B120; // (error 101)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      L     #NofRCV_Bytes;
      T     "BasicData".Info2;
      UC    "Diagnose"; //THEN send error message: receive buffer contents fault

      JU    BEND;

Chck: L     DIB [#RCV_BufferPointer]; //check block length of all received messages
      T     #MessageLength; //load message block length
      L     0;
      ==I   ; //IF block length of message = 0
      JCN   Go01;

      =     #RCV_BuffContentsFault; //receive buffer contents fault occured
      L     W#16#B121; // (error 102)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;
      UC    "Diagnose"; //THEN send error message: receive buffer contents fault

      JU    BEND;

Go01: L     #NofRCV_Bytes; //ELSE check length of messages
      L     #MessageLength;
      -I    ;
      T     #NofRCV_Bytes; //IF no. of bytes of all received messages
      L     0; // > no. of bytes of current received block
      <I    ;
      JCN   Go02;

      =     #RCV_BuffContentsFault; //receive buffer contents fault occured
      L     W#16#B122; // (error 103)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;
      UC    "Diagnose"; //THEN send error message: receive buffer contents fault

      JU    BEND;

Go02: ==I   ; //IF no. received bytes - no. of bytes of all messages = 0
      JC    OK; //THEN received buffer contents is ok

      L     #RCV_BufferPointer; //ELSE
      L     #MessageLength; //calculate pointer to next message
      SLD   3;
      +D    ;
      T     #RCV_BufferPointer;
      JU    Chck; //end of check loop

NETWORK
TITLE =copy of received messages required
//check DB no. for copy and call FC_RcvCopy
OK:   S     #RCV_MessageExists;

P1:   L     DIW   10; //start address of receive buffer = address of first message
      SLD   3;
      T     #RCV_BufferPointer; //set pointer to first message again
      LAR1  ;
      L     DIB [#RCV_BufferPointer]; //block length of received message
      T     #MessageLength;

NETWORK
TITLE = Loop over all messages in the received block
// generell checks and pointer presets
//
//check no. of remote partner and subscriber address length
P11:  L     0; //preset at the begin of processing of each message
      T     #TempIntegerBuffer;

      L     DIB [AR1,P#5.0]; //load: no. of remote partner / subscriber address length
      SRW   4;
      T     #NofDestSubscr;
      L     1;
      >I    ; //IF no. of destination subscribers > 1
      JCN   Go03;

      L     W#16#B123; // (error 104)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      L     #NofDestSubscr;
      T     "BasicData".Info2;
      UC    "Diagnose"; //THEN send error message: no. of destination subscribers > 1

      JU    P5;

Go03: L     DIB [AR1,P#5.0]; //ELSE check subscriber address length
      AW    W#16#F;
      L     2;
      <>I   ; //IF subscriber address length >< 2
      JCN   Go04;

      L     W#16#B124; // (error 105)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      L     DIB [AR1,P#5.0];
      T     "BasicData".Info2;
      UC    "Diagnose"; //THEN send error message: subscriber address length >< 2

      JU    P5;

//calculate address of start index (pointer)

Go04: L     #NofDestSubscr; //no of destination subscribers
      L     0;
      ==I   ; //IF no of destination subscriber = 0
      L     #RCV_BufferPointer;
      JC    CaLo; //THEN calculate address of start index low: add 10 after SLW3
      +     L#112;
      JU    CaHi; //ELSE calculate address of start index high: 14 after SLW3

CaLo: +     L#80;

CaHi: T     #AddressStartIndexNo; //pointer to start index no.

      L     DIW [#AddressStartIndexNo];
      T     #StartIndexNo;

//calculate first data address (pointer)

      AN    DIX [AR1,P#3.4]; //IF time stamp not exists (Z flag = 0)
      L     #AddressStartIndexNo;
      JC    DaLo; //THEN calculate address of data low: add 2 after SLW3
      +     L#80;
      JU    DaHi; //ELSE calculate address of data high: add 10 after SLW3

DaLo: +     L#16;

DaHi: T     #AddressFirstData; //pointer to first data byte of current message

//calculate no. of received (clear) data bytes

      L     #RCV_BufferPointer; //address of current message
      SRD   3; //  +
      L     DIB [#RCV_BufferPointer]; //length of current message
      +I    ; //  -
      L     #AddressFirstData; //address of first (clear) data
      SRD   3;
      -I    ; //  =
      T     #NofRCV_ClearData; //no. of received (clear) data

//check org. message 256

      L     0; //IF clear data are not 0, it could not be org. message 256
      <>I   ;
      O(    ;
      O     DIX [AR1,P#3.6]; //IF TA code is not 0 it could not be org. message 256
      O     DIX [AR1,P#3.7];
      )     ;
      O(    ;
      L     DIW [AR1,P#8.0]; //IF destination object no. is not 7FFF it could not be org. message 256
      L     W#16#7FFF;
      <>I   ;
      )     ;
      O(    ;
      L     256;
      L     #StartIndexNo; //IF start index no is not 256 it could not be org. message 256
      <>I   ;
      )     ;
      JC    N256; //message is not org. 256

//enter time of org. message 256 into BasicData and set TIM clock status to true

      S     "BasicData".TimClockOk; //TIM only sends a org. PDU 256 when time status is valid
      L     DID [AR1,P#16.0];
      T     "BasicData".LastSyncDate;
      L     DID [AR1,P#20.0];
      T     "BasicData".LastSyncTime;

      JU    P5; //go on with next message

//check org. message 2: "general request start" whether it is received with AE=0 or AE=2
//identifying general request start

N256: O(    ;
      O     DIX [AR1,P#3.6]; //IF TA code is not 0 it could not be required org. message 2
      O     DIX [AR1,P#3.7];
      )     ;
      O(    ;
      L     DIW [AR1,P#8.0]; //OR destination object no. is not 7FFF it could not be org. message 256
      L     W#16#7FFF;
      <>I   ;
      )     ;
      O(    ;
      L     L#2;
      L     #StartIndexNo; //OR start index no is not 2 it could not be org. message 2
      <>I   ;
      )     ;
      O(    ;
      L     DIW [#AddressFirstData]; //OR index has not a length of 4 byte
      L     4;
      <>I   ;
      )     ;
      JC    NGRS; //THEN message is not index 2

//check whether index 2 contained "general request start" flag

      L     #AddressFirstData;
      +     L#32; //add 4 after slw 3
      T     #TempBuffer; //address of contents of receive index 2
      L     DIW [#TempBuffer]; //load contents of receive index 2
      L     2; //IF contents is not 2
      <>I   ;
      JC    NGRS; //THEN message is not general request start

//check AE code

      AN    DIX [AR1,P#1.1]; //IF AE = 2
      A     DIX [AR1,P#1.2];
      L     -2;
      JC    NGRE; //no general request end must be created

      L     -1; //ELSE code -1 = "general request end" must be created
NGRE: T     #TempIntegerBuffer; //remember whether request end must be created by CPU

//continue with entrys which were blocked last cycle

NGRS: A     #SubscriberObjectBlocked; //IF entry to subscriber object was blocked last cycle
      JC    P4; //THEN do entry in subscriber object now (at point 4)

      A     #ProcessObjectBlocked; //IF entry to process object was blocked last cycle
      JC    P3; //THEN do entry in process object now (at point 3)

//check message type

      L     DIW [AR1,P#8.0]; //load destination object no.
      A     DIX [AR1,P#3.7]; //IF TA = 2/3 => it is a process data message
      JC    PrOb; //THEN  do entry in process object

NETWORK
TITLE = pre processing of organisational messages
// check no. of destination subscribers
      L     #NofDestSubscr;
      L     1;
      ==I   ; //IF no. of destination subscriber is 0 (message to all subscribers)
      JC    Go05;

      L     W#16#B125; //(error 106)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      L     #NofDestSubscr;
      T     "BasicData".Info2;
      UC    "Diagnose"; //THEN send error message: no. of destination subscribers <> 1
//(not allowed with organisational messages)
      JU    P5;

//check address extension AE = 2 then it is a ST7 organisational message

Go05: L     DIB [AR1,P#1.0];
      SRW   1;
      AW    W#16#3;
      L     2; //IF address extension is not 2
      ==I   ;
      JCN   CAE0; //THEN check address extension 0
      L     DIW [AR1,P#8.0]; //ELSE check destination object no.
      L     W#16#7FFF;
      ==I   ; //IF destination object no. is coded for subscriber object
      JC    P4; //THEN do entry in subscriber object (at point 4)
      TAK   ; //(destination object code is in accu 1 again)
PrOb: L     0; //ELSE check 0 < destination no. <= 32 000:
      >=I   ; //IF object no. is not > 0

      JCN   Go06; //THEN send diagnose message (error code = 108)
      TAK   ; //(destination object no. in accu 1 again)
      L     32000;
      >=I   ; //IF object no. is > 32 000
      JC    Go06; //THEN send diagnose message (error code = 108)

      JU    P3; //END IF: do entry in process object

Go06: L     W#16#B128; //(error 40)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      L     DIW [AR1,P#8.0];
      T     "BasicData".Info2;
      UC    "Diagnose"; //send error message: 0 < destination no. <= 32 000

      JU    P5;

//check address extension AE = 0 then it is a ST1 organisational message

CAE0: TAK   ; //(address extension is in accu 1 again)
      L     0;
      ==I   ; //IF address extension NOT 0
      TAK   ; //(address extension is in accu 1 again)
      JC    Go07;

      T     "BasicData".Info2;
      L     W#16#B126; //(error 38)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      UC    "Diagnose"; //send error message: address extension NOT 0

      JU    P5;

Go07: L     DIW [AR1,P#8.0]; //ELSE check destination object no.
      L     0;
      ==I   ; //IF destination object no. NOT 0
      JCN   Cson; //THEN check source object no.
      L     DIW [AR1,P#12.0]; //If source object no. is not 7FFF
      L     W#16#7FFF;
      ==I   ;
      JC    Go09;

      TAK   ; //undefined ST1 source object no.:
      T     "BasicData".Info2;
      L     W#16#B129; //(error 41)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      UC    "Diagnose"; //send error message: source object no. is not 0

      JU    P5;

Go09: T     DIW [AR1,P#8.0]; //ELSE copy 7FFF to Destination object no. of receive message

Cson: L     DIW [AR1,P#12.0]; //check source object no.
      L     W#16#7FFF;
      ==I   ; //IF source object no. = 7FFF
      JC    Crel; //THEN check relevant subscriber/object no.
      TAK   ; //ELSE
      L     0;
      ==I   ; //IF source object no. is not 0
      JC    P3;

      TAK   ; //undefined ST1 source object no.:
      T     "BasicData".Info2;
      L     W#16#B129; //(error 41)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      UC    "Diagnose"; //send error message: source object no. is not 0

      JU    P5;

Crel: L     DIW [AR1,P#18.0]; //check relevant subscriber/object no.
      L     0;
      ==I   ; //IF no. = 0 (then ST1 store counter message)
      JCN   P4; //THEN entry in subscriber object
      SET   ; //ELSE set flag to restoring counter values
      =     "BasicData".CounterValueStorage;

      JU    P5; //go on with processing the next message


NETWORK
TITLE = entry in process data object
//check AE-code of the message, AE=3 is not permissible
P3:   L     3;
      L     DIB [AR1,P#1.0]; //If AE = 3
      SLW   13;
      SRW   14;
      <>I   ;
      JC    P3_1;

      T     "BasicData".Info2; //THEN send a diagnose message
      L     W#16#B127; //(error 39)
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;
      UC    "Diagnose";

      JU    P5; //and continue with next message

P3_1: L     #NofDestSubscr; //check no. of destination subscribers
      L     0;
      ==I   ; //IF no. of subscriber = 0
      JC    SOL1; //THEN have a look at object reference list 1 (source is given)
      L     DIW [AR1,P#8.0]; //ELSE check destination object no.
      L     0;
      ==I   ; //IF destination object no. = 0
      JC    SOL1; //THEN have a look at object reference list 1 (source is given)

      L     DID [AR1,P#8.0]; //store source subscriber address / destination object no.
      RLD   16; //for later diagnostics message
      T     #TempBuffer;
      L     DIW [AR1,P#8.0]; //destination object no.
      T     #TempBlockNo; //temporary DI / DB
      A     DIX [AR1,P#1.2]; //IF current message is no ST1 message (AE must be 0 or 1)
      JC    ST7; //THEN do entry in process object

      L     DID [AR1,P#6.0]; //IF current message is an organisational message (TA=0 or 1)
      T     #TempBuffer; //store destination address
      AN    DIX [AR1,P#3.7]; //IF current message is an organisational message (TA=0 or 1)
      JC    DOL2; //THEN have a look at object reference list 2
      JU    DOL1; //ELSE check object list 1 for an entry while destination is given

//check object list 1 for an entry while source subscriber and surce object is given

SOL1: L     DID [AR1,P#10.0]; //search for source address
      T     #TempBuffer;

DOL1: AN    "BasicData".ObjRefListGenActive;
      AN    "BasicData".ObjRefList1_Avail;
      JCN   Go08;

      AD    DW#16#FFFF;
      T     "BasicData".Info2;
      L     #TempBuffer;
      SRD   16;
      T     "BasicData".Info1;
      L     W#16#B109; //(error 9)
      T     "BasicData".EventID;

      UC    "Diagnose"; //send error message: object reference list 1 not available

      JU    P5;

Go08: A     "BasicData".ObjRefListGenActive;
      BEC   ; //wait state

//open objectlist 1

      L     "BasicData".DB_ObjectList1; //ELSE
      T     #TempBlockNo; //temporary DB
      L     "BasicData".NofObjectItems1;
      T     #TempIntegerBuffer;
      OPN   DB [#TempBlockNo]; //open object list 1	for searching

      CALL "Search" (//search for local object no.
           NofObjects               := #TempIntegerBuffer,//no. of objects in reference list 1
           ObjectLength             := 6,
           StartAddress             := W#16#2,
           CodeWanted               := #TempBuffer,
           CodeMask                 := DW#16#FFFFFFFF,
           RET_VAL                  := #FoundedAddress);

//check success of FC Search

      L     L#0;
      L     #FoundedAddress;
      >=D   ; //IF local object DB not found
      JCN   ST1;

      L     #TempBuffer;
      AD    DW#16#FFFF;
      T     "BasicData".Info2;
      L     #TempBuffer;
      SRD   16;
      T     "BasicData".Info1;
      L     W#16#B10B;
      T     "BasicData".EventID; //(error 11)

      UC    "Diagnose"; //send error message: object reference list 1 not available

      JU    P5;

//check object list 2 for an entry while destination subscriber and destination object of an
//organisational message is given (i.ex. specific request or message termination/clearance)

DOL2: AN    "BasicData".ObjRefListGenActive;
      AN    "BasicData".ObjRefList2_Avail;
      JCN   Go10;

      AD    DW#16#FFFF;
      T     "BasicData".Info2;
      L     #TempBuffer;
      SRD   16;
      T     "BasicData".Info1;
      L     W#16#B10A; //(error 10)
      T     "BasicData".EventID;

      UC    "Diagnose"; //send error message: object reference list 2 not available

      JU    P5;

Go10: A     "BasicData".ObjRefListGenActive;
      BEC   ; //wait state

//open objectlist 2

      L     "BasicData".DB_ObjectList2;
      T     #TempBlockNo; //temporary DB
      L     "BasicData".NofObjectItems2;
      T     #TempIntegerBuffer;
      OPN   DB [#TempBlockNo]; //open object list 2 for searching

      CALL "Search" (//search for local object no.
           NofObjects               := #TempIntegerBuffer,//no. items in object reference list 2
           ObjectLength             := 6,
           StartAddress             := W#16#2,
           CodeWanted               := #TempBuffer,
           CodeMask                 := DW#16#FFFFFFFF,
           RET_VAL                  := #FoundedAddress);

//check success of FC Search

      L     0;
      L     #FoundedAddress;
      >=D   ; //IF local object DB not found
      JCN   ST1;

      L     W#16#B10C; //(error 12)
      T     "BasicData".EventID;

ObDB: L     #TempBuffer;
      AD    DW#16#FFFF; //destination object no.
      T     "BasicData".Info1;
      L     #TempBuffer;
      SRD   16;
      T     "BasicData".Info2;

      UC    "Diagnose"; //send error message: object reference list 1 not available

      JU    P5;

ST1:  L     #FoundedAddress; //calculate pointer to local object DB no. in object list 1/2
      SLD   3;
      LAR2  ;
      L     DBW [AR2,P#4.0]; //load local process data object
      T     #TempBlockNo; //temporary DI / DB

//check whether required destination object is available

ST7:  L     W#16#B115; //load ID in case object DB will not be found
      T     "BasicData".EventID;
      SET   ;
      S     "BasicData".ObjectDB_Available; //OB121 can reset this flag if DB is not available
      OPN   DB [#TempBlockNo]; //open process data object =>if DB not available OB121 is called
      A     "BasicData".ObjectDB_Available; //object DB available?
      R     "BasicData".ObjectDB_Available;
      JCN   ObDB; //object DB missed=> send CPU diagnostics message and continue at P5

      OPN   DI [#XComData]; //open DB XComData

//check whether it is an ST1 message in command direction

      AN    DIX [AR1,P#1.2]; //IF current message is a ST1 message (AE must be 0 or 1)
      A     DIX [AR1,P#1.0]; //AND current message is in command direction
      JC    Clr; //THEN no check of source address is possible => go on at lable clr

//check received source address (source subscriber no. and source object no.)

      L     DIW [AR1,P#10.0]; //check whether source subscriber is known
      SLD   16;
      T     #TempBuffer;

      CALL "Search" (//search for source subscriber object block
           NofObjects               := "BasicData".NofSubscrObjects,//no. of subscriber objects
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #TempBuffer,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #FoundedAddress);

//check success

      L     L#0; //IF founded address is not negative
      L     #FoundedAddress;
      <D    ;
      JC    AFnd; //THEN address found => partner subscriber is known

      L     W#16#B12F; //ELSE received message for object [Info1] not accepted, source subscr. no. unknown
DCM1: T     "BasicData".EventID;
      L     DIW [AR1,P#10.0]; //source subscriber no.
DCM2: T     "BasicData".Info2; //source subscriber no. or source object no.
      L     #TempBlockNo; //own object no.
      T     "BasicData".Info1; //destination object no.

      UC    "Diagnose"; //display error message	to CPU diagnostics buffer										//is not <= address of org. index 0

      JU    P5; //go on with processing the next message

//check remote subscriber type whether it is an SMSC

AFnd: SLD   3; //IF remote subscriber type is a SMSC
      LAR2  ;
      L     7;
      L     DBB [AR2,P#6.0]; //THEN no further checks are necessary
      ==I   ; //because the sms typical does the checks itself
      OPN   DB [#TempBlockNo]; //reopen process data object
      JC    Clr; //go on at lable Clr

//check partner subscriber no. and partner object no.

      L     0; //IF expected remote Partner no. = 0 => messages from all partners
      L     DBW    0; //will be accepted
      ==I   ;
      JC    CPOI; //THEN check partner object number

      L     DIW [AR1,P#10.0]; //IF own remote partner no. = source partner no. of the message
      ==I   ;
      JC    CPOI; //THEN check partner object no.

      L     W#16#B130; //ELSE received message not accepted, wrong source subscr. no.
      JU    DCM1;

CPOI: A     DIX [AR1,P#1.1]; //If current message is a ST1 message with AE = 1
      AN    DIX [AR1,P#1.2];
      JCN   CPON; //If AE = 0,2,3 then jump CPON an check partner object no
//If AE = 1 then check ST1MessageNo and ST1ObjectNo and ST1IndexNo
      L     DBW    2; //load ST1MessageNo
      SLW   8; //shift into high byte
      L     DBW    4; //load ST1ObjectNo
      OW    ; // high byte = ST1MessageNo / low byte = ST1ObjectNo
      SLD   16; //shift into high Word
      L     DBW    6; //load ST1IndexNo
      SLW   1; //multiply ST1IndexNo by 2
      OD    ; //highword = ST1MessageNo and ST1ObjectNo / lowword = ST1IndexNo
      L     DID [AR1,P#12.0]; //
      ==D   ; //check address of received ST1 Message
      JC    Clr; //Adress in received ST1 Message is o.k.
      JU    B131; //Enter ErrorMessage

//check partner object no.

CPON: L     0; //IF partner object no. = 0 => data from all partner objects are permitted
      L     DBW    2;
      ==I   ;
      JC    Clr; //THEN clearence for entry

      L     DIW [AR1,P#12.0]; //IF remote object no. from current received message = 0
      ==I   ;
      JC    Clr; //THEN clearence for entry

B131: L     W#16#B131; //ELSE received message not accepted, wrong source object no.
      T     "BasicData".EventID;
      TAK   ;
      JU    DCM2; //send a diagnostics message to CPU diagnostics buffer

//calculate object DB pointers and preset of local control flags EZ/EA/SZ

Clr:  OPN   DB [#TempBlockNo]; //reopen process data object
      L     DBLG;
      +     L#-8;
      SLD   3;
      T     #TempBuffer; //pointer to start of object base = start address of data index 0
      LAR2  ;

      L     DBB [AR2,P#7.0]; //EZ/EA/SZ flags of process object data block
      LAR2  P##SpaceForSendMessExists;
      T     LB [AR2,P#0.0]; //preset local control flags
      LAR2  #TempBuffer;

      L     DBW [AR2,P#2.0]; //address organisation index 0
      SLD   3;
      T     #OrgIndex0; //pointer to organisation index 0

//check ST7 process object registration code

      L     DBB [AR2,P#6.0];
      L     B#16#A5;
      ==I   ; //IF process object registration code is not "A5"
      JC    Go11;

      L     DBNO;
      T     "BasicData".Info1;
      L     W#16#B10D;
      T     "BasicData".EventID; //(error 13)
      L     0;
      T     "BasicData".Info2;

      UC    "Diagnose"; //send error message: process object registration code is not "A5"

      JU    P5;

//check whether entry into current process object DB is blocked

Go11: A     DBX [AR2,P#7.3]; //IF receive data brake is true
      BEC   ; //THEN no further action => wait state

      TAR2  #TempBuffer; //address pointer to start of object base = start address of data index 0
      L     DBW [AR2,P#2.0]; //load address of org index 0 in data object
      SLD   3;
      LAR2  ; //start address of org index 0
      AN    DBX [AR2,P#2.1]; //If process data entry is blocked no enter of process data happends
      LAR2  #TempBuffer;
      JC    P5; //go on with next message

//check whether entry into current process object DB is blocked

      L     DBB [AR2,P#4.0]; //load no. of received bytes
      L     0;
      ==I   ; //IF entry for new data is not clear
      JCN   Cpos; //THEN check whether new entry is possible
      R     #ProcessObjectBlocked; //ELSE
      JU    CMT; //clear "entry blocked" go to check
// message type
Cpos: AN    #ProcessObjectBlocked; //IF	process object is not blocked,
      S     #ProcessObjectBlocked;
      JC    BEND; //THEN no entry, block it and wait one cycle

//check message type of process object and do the entry

CMT:  AN    DIX [AR1,P#3.7]; //IF it is not an organisational message
      JCN   EnPD; //THEN goto entry of process data
//ELSE

//entry of organisational message data into the process object DB

//check the possibility of entry

      L     #StartIndexNo;
      L     0; //check organisational message header before entry
      ==I   ;
      A(    ;
      L     #NofRCV_ClearData;
      L     6;
      ==I   ; //IF start index is not 0 and no. of received clear bytes
      )     ; //are not 6 bytes
      JC    Go12;

      L     #NofRCV_ClearData; //IF error no. of clear data
      ==I   ;
      L     W#16#B12B; //THEN send error message no. 43
      JC    Entr;

      L     W#16#B12A; //ELSE send error message no. 42
Entr: T     "BasicData".EventID;
      L     #XComData; //add info 1: current communication DB
      T     "BasicData".Info1;
      L     DIW [AR1,P#8.0]; //add info 2: current destination object no.
      T     "BasicData".Info2;

      UC    "Diagnose"; //send error message: start index is not 0 and no. of
//received clear bytes are not 6 bytes
      JU    P5;

Go12: L     #AddressFirstData; //ELSE correct message header and do the entry
      +     L#32; //add 4 after SLD 3 => index 0 begining
      T     #AddressFirstData;
      L     2; //contents of organisational message is index 0
      T     #NofRCV_ClearData; //and index 0 has 2 bytes
      T     DBB [AR2,P#4.0]; //enter the no. of received bytes

//entry of organisational message INDEX 0 into process object DB

      L     DIW [#AddressFirstData]; //fetch received data
      LAR2  #OrgIndex0; //set pointer to organisation index 0 of object data
      L     DBW [AR2,P#0.0]; //fetch index 0 of process object
      OW    ; //set received flags into the index 0 of
      T     DBW [AR2,P#0.0]; //process object

      JU    P7; //finish the process object entry

//entry of process data into the process object DB

EnPD: L     0;
      L     #StartIndexNo; //check start index: index < 0 not allowed
      <=I   ;
      JC    Go13;

      L     0; //display diagnostics message: index is nagative
      T     "BasicData".Info2;
      L     W#16#B134;
      T     "BasicData".EventID; //(error 52)
      L     #XComData;
      T     "BasicData".Info1;

      UC    "Diagnose"; //send error message: start index is not 0 and no. of
//received clear bytes are not 6 bytes
      JU    P5;

//check whether current no. of process data bytes are allowed

Go13: L     #NofRCV_ClearData; //received no. process data bytes
      L     DBB [AR2,P#5.0]; //> max. no. of data bytes
      <=I   ; //IF no. of received clear data bytes > no. of max. allowed bytes
      JCN   Dia2; //THEN dispay a diagnostics message

//check if current process data start index no. is possible

      L     DBW [AR2,P#0.0]; //address of data index 0
      L     #StartIndexNo; // + start index no.
      +I    ; // + clear data bytes
      L     #NofRCV_ClearData; // = max. address
      +I    ;
      L     DBW [AR2,P#2.0]; //address of org. index 0
      <=I   ; //IF current last data address < address of org index 0
      JC    Go14; //THEN go on

Dia2: L     DBNO;
      T     "BasicData".Info2;
      L     W#16#B12C; //ELSE send error message 44
      T     "BasicData".EventID;
      L     #XComData;
      T     "BasicData".Info1;

      UC    "Diagnose"; //current max. data index address
//is not <= address of org. index 0
      JU    P5;

//enter no. of received bytes in process object

Go14: L     #NofRCV_ClearData;
      T     DBB [AR2,P#4.0];

//preset pointers for entry of received process data into process object DB

      L     DBW [AR2,P#0.0]; //calculate address for clear data in the
      L     #StartIndexNo; //process object
      +I    ;
      SLD   3;
      LAR2  ; //set destination pointer in process object
      LAR1  #AddressFirstData; //set source pointer in received message

//enter clear data from received message into process data object

Loop: L     1; //DO WHILE no. of received clear data is not <= 1 byte
      L     #NofRCV_ClearData;
      >=I   ;
      JC    P7; //finish the process object entry

      +     -2;
      T     #NofRCV_ClearData;
      L     DIW [AR1,P#0.0]; //load clear data of received message
      T     DBW [AR2,P#0.0]; //and store it in process object DB
      +AR1  P#2.0;
      +AR2  P#2.0;
      JU    Loop; //END DO


//finish the process object entry

//copy F3 and F4 code from received message into object data block

P7:   LAR1  #RCV_BufferPointer; //pointing to DB XComData (DB) first current message address
      LAR2  #OrgIndex0; //pointer to organisation index 0
      L     DIW [AR1,P#3.0]; //F3 and F4 code
      T     DBW [AR2,P#4.0]; //entry

//only for extended version: additional entrys of source subscriber address
//and time stamp of received message into the process object data block

      L     #AddressStartIndexNo; //calculate pointer to source address in received message
      +     L#-32; //add -4 after SLD 3
      LAR1  ;
      LAR2  #OrgIndex0; //set pointer to org index 0 again

//copy source subscriber no. and source object no. from received message into object data block

      A     DBX [AR2,P#4.4]; //note whether the message has a time stamp for later
      =     #MessageTimeStampExists;

      AN    #SpaceForAddressExists; //IF destination data object is without extension (EA><0)
      JC    NoAd; //THEN goto no extension
//ELSE
      L     DID [AR1,P#0.0]; //enter source subscriber no. and source object no.
      T     DBD [AR2,P#6.0]; //and
      L     DIW [AR1,P#4.0]; //enter start index no.
      T     DBW [AR2,P#10.0]; //of received message into process data object
      +AR2  P#6.0; //time stamp is 6 bytes behind

//copy time stamp of received message into object data block

NoAd: ON    #MessageTimeStampExists; //IF message has no time stamp or there is no space for
      ON    #SpaceForTimeStampExists; //entry of received time stamp
      JC    NoTi; //THEN goto no extension

      LAR1  #AddressStartIndexNo; //ELSE
      L     DID [AR1,P#2.0]; //enter time stamp of received message
      T     DBD [AR2,P#6.0]; //into process object data block
      L     DID [AR1,P#6.0];
      T     DBD [AR2,P#10.0];

//check whether data loss of process object occured

NoTi: LAR2  #OrgIndex0; //set pointer to org index 0 again
      A     #ProcessObjectBlocked; //IF process object was blocked 1 cycle before
      R     #ProcessObjectBlocked; //THEN unlock for further entrys
      S     DBX [AR2,P#5.7]; //set flag for "data loss occured"
      JCN   P5;

      L     DBNO;
      T     "BasicData".Info1;
      L     W#16#B190;
      T     "BasicData".EventID; //(error 144)
      L     0;
      T     "BasicData".Info2;

      UC    "Diagnose"; //send error message: data loss occured											//is not <= address of org. index 0

      JU    P5; //go on with processing the next message


NETWORK
TITLE = entry into subscriber object

P4:   L     DIW [#AddressFirstData]; //length of the organisation segments
      T     #OrgSegmentLength;

      A     #SubscriberObjectBlocked; //IF entry into subscriber object was blocked last cycle
      JC    P10; //THEN do not calculate current org segmet address
//once more
      L     #AddressFirstData; //ELSE
      SRD   3;
      +     2; //calculate current org. segment address
      T     DIW   12;

//Loop for processing all segments of the organisational message

P10:  L     DIW   12; //set XComData address to current org. segment address
      SLD   3;
      LAR2  ;
      L     DID [AR2,P#0.0];
      T     #TempBuffer;

      CALL "Search" (//ELSE search for subscriber object
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #TempBuffer,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #FoundedAddress);

//check success

      L     L#0;
      L     #FoundedAddress; //address of subscriber object
      <D    ; //IF subscriber object address found
      JC    SuOk; //THEN go on processing at subscriber address ok

      L     W#16#B12D;
      T     "BasicData".EventID; //(error 45)
      L     #XComData;
      T     "BasicData".Info1;
      L     #TempBuffer; //rel. subscriber no.
      SRD   16;
      T     "BasicData".Info2;

      UC    "Diagnose"; //send error message: required subscriber object not found											//is not <= address of org. index 0

      JU    P5; //go on with processing the next message

SuOk: SLD   3; //set DB BasicData address to start of subscriber object
      LAR1  ;
      L     DBB [AR1,P#16.0]; //load no. of received bytes (last time)
      L     0;
      <>I   ; //check whether subscriber object is blocked
      SAVE  ; //save VKE: BIE=1 when object processing is ready
      AN    #SubscriberObjectBlocked; //IF subcriber object is not blocked
      S     #SubscriberObjectBlocked; //THEN block subscriber object for 1 cycle
      JC    BEND; //and end

      AN    BR; //IF subscriber object processing is ready
      R     #SubscriberObjectBlocked; //THEN clear subscriber object entry blocking

//calculate no. of received organisation index bytes

      L     #OrgSegmentLength;
      +     -2;
      T     #NofRCV_OrgIndexBytes;

//calculate start of subscriber object receive block

      L     #FoundedAddress; //address of subscriber object
      L     "BasicData".OffsetRcvOrgIndex0;
      +I    ;
      T     #StartSubscriberRcvBlock;

//calculate start of subscriber object send block

      L     "BasicData".SubscrObjectLength;
      L     "BasicData".OffsetRcvOrgIndex0;
      -I    ;
      SRW   1;
      L     #StartSubscriberRcvBlock;
      +I    ;
      T     #StartSubscriberSendBlock;

//check whether received length of organisational segment matches with
//receive buffer length of subscriber object

      L     #StartSubscriberRcvBlock;
      L     #StartIndexNo;
      +I    ;
      SLD   3;
      LAR1  ; //set DB BasicData pointer to start of subscriber RCV index
      SRD   3;
      L     #NofRCV_OrgIndexBytes;
      +I    ;
      L     #StartSubscriberSendBlock;
      <=I   ; //IF data block is too long
      JC    CoIn;

      L     #TempBuffer; //rel. subscriber no.
      SRD   16;
      T     "BasicData".Info2;
      L     W#16#B12E;
      T     "BasicData".EventID; //(error 46)
      L     #XComData;
      T     "BasicData".Info1;

      UC    "Diagnose"; //THEN send error message: entry is not permissible											//is not <= address of org. index 0

      JU    P5; //go on with processing the next message

//copy received index data to subscriber object receive buffer

CoIn: L     DIW [AR2,P#2.0];
      T     DBW [AR1,P#0.0];
      +AR1  P#2.0;
      +AR2  P#2.0;
      L     #NofRCV_OrgIndexBytes;
      +     -2;
      T     #NofRCV_OrgIndexBytes;
      L     0;
      >I    ;
      JC    CoIn;

//set flag for generating the "GR-end"-message (necessary if ST1 protocol is used for this subscriber)

      L     #StartSubscriberSendBlock;
      SLD   3;
      LAR1  ; //set DB BasicData pointer to start of subscriber send index
      L     -1;
      L     #TempIntegerBuffer; //IF code for creating of GR-end messages is -1
      ==I   ;
      S     DBX [AR1,P#5.6]; //THEN set flag for create general request end by CPU

      L     -2; //IF code = -2 (AE = 2)
      ==I   ;
      R     DBX [AR1,P#5.6]; //THEN do not create general request end by CPU

//set pointer to address of subscriber object in DB Basic Data

      L     #FoundedAddress;
      SLD   3;
      LAR1  ;
      LAR2  #RCV_BufferPointer; //address of current received organisational message (DB XCom)

//copy no. of received bytes and F3,F4 fields into the subscriber object

      L     #OrgSegmentLength;
      +     -2;
      T     DBB [AR1,P#16.0]; //enter no. of entered bytes
      L     DIW [AR2,P#3.0];
      T     DBW [AR1,P#18.0]; //enter F3 and F4 fields

//copy source subscriber no., source object no. and index no. into subscriber object

      L     #AddressStartIndexNo; //address of DB XCom => source subscriber no. and object no.
      +     L#-32;
      LAR2  ;
      L     DID [AR2,P#0.0];
      T     DBD [AR1,P#20.0]; //enter source subscriber address
      L     #StartIndexNo;
      T     DBW [AR1,P#24.0]; //enter received start index

//check whether time stamp exists and copy it from received message into subscriber object

      A     DBX [AR1,P#18.4]; //IF NOT received message has time stamp (Z=1) and
      A     DBX [AR1,P#3.0]; //subscriber object has a time stamp feld (EZ=1)
      JCN   ChTo; //THEN go on with check subscriber block bit

      L     DID [AR2,P#6.0]; //ELSE copy time stamp from received message
      T     DBD [AR1,P#26.0]; //to subscriber object
      L     DID [AR2,P#10.0];
      T     DBD [AR1,P#30.0];

ChTo: A     #SubscriberObjectBlocked; //IF entry in subscriber was blocked,
      R     #SubscriberObjectBlocked; //THEN clear "entry blocked"
      S     DBX [AR1,P#19.7]; //set flag for "data loss occured"
      JCN   Go15; //ELSE go on

      L     #TempBuffer; //rel. subscriber no.
      SRD   16;
      T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;
      L     W#16#B191;
      T     "BasicData".EventID; //(error 145)

      UC    "Diagnose"; //send error message: subscriber data loss occured

      JU    P5; //go on with processing the next message

//calculate next address of organsational segment of received message

Go15: L     DIW   12;
      L     #OrgSegmentLength;
      +I    ;
      T     DIW   12;

//check whether all organisational segments are processed

      L     #RCV_BufferPointer; //pointer to start of current message
      SRD   3; //address of current message
      L     DIB [#RCV_BufferPointer]; //current message block length
      +I    ;
      L     DIW   12; //IF last message byte address is > then
      >I    ; //current segment address
      JC    P10; //THEN go on with processing next organisational segment

//ELSE foreward loop over message processing

P5:   L     0; //check whether FC user exists
      L     "BasicData".FC_User;
      <I    ; //IF FC USER of DB Basic Data is > 0
      JCN   Cont; //THEN continue

      T     #TempBlockNo; //ELSE call FC user
      UC    FC [#TempBlockNo];

//calculate start of next message in receive buffer

Cont: L     #RCV_BufferPointer;
      SRD   3;
      L     #MessageLength;
      +I    ;
      T     DIW   10;
      SLD   3;
      T     #RCV_BufferPointer;
      LAR1  ;

//load new message length

      L     DIB [#RCV_BufferPointer]; //block length of received message
      T     #MessageLength;

//check whether the end of receive buffer is reached

      L     #RCV_BufferPointer;
      SRD   3;
      L     DIW    6; //start address of receive buffer
      -I    ;
      L     DIW   14;
      ==I   ; //IF the end of the received block is not reached
      JCN   P11; //THEN go processing next message

//END Loop over all messages in the received block

//IF no more receive message is existing

      SET   ;
      R     #RCV_MessageExists; //reset message existing flag

//restore current data of DB XComData

BEND: OPN   DI [#XComData]; //DB XComData neu öffnen
      LAR1  P##RCV_MessageExists; //start address of local flag
      L     LB [AR1,P#0.0]; //loading local flags
      T     DIB   16; //restore global flag byte

END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION "Create" : VOID
TITLE =	Create
//
//	This FC creates data messages and organisational messages from process data objects or technologie
//	typicals and it creates organisational messages
//
//
//	Input parameter description:
//	SubscriberObject:	true 	= subscriber object
//				false 	= process data object / technologie typical
//
//
//Message	Event ID´s:	Info1:			Info2:
// no.
//(13) 	B10D		DB-No.			0				data object DB is not ST7 coded
//(69)		B145		SrcObjNo/7FFF		DestSubscrNo			data message fault
//(70)		B146		SrcObjNo		DestSubscrNo			org. message fault
//
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : Create
VERSION : 1.5


VAR_INPUT
  SubscriberObject : BOOL ;	//true = subscriber object, false = process data object
END_VAR
VAR_TEMP
  CurrentComDB : INT ;
  CurrentMessageLength : INT ;
  CurrentIndex : INT ;
  LoopCounter1 : INT ;
  LoopCounter2 : INT ;
  SubscrAddress : DWORD ;
  TempPointer1 : DWORD ;
  TempPointer2 : DWORD ;
  TempPointer3 : DWORD ;
  TempBuffer : DWORD ;
  ConnectionStatus : BOOL ;
  WaitForEntry : BOOL ;
  TimeStamp : BOOL ;
  MessageToAll : BOOL ;
  OrgData : BOOL ;	//message of a process / data typical is a org. message
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!
RUN:  NOP   0;
NETWORK
TITLE =
//check type of object
      AN    #SubscriberObject; //IF not subscriber object
      JC    DaOb; //THEN the source is a data object

      L     "BasicData".CurrentComDB; //ELSE the source is a subscriber object
      T     #CurrentComDB;
      R     #MessageToAll; //no message to all when it is a message of subscriber object

//preset the address pointer 1 to start of the source message and address pointer 2 to the management

      L     "BasicData".StartOrgSendData;
      SLD   3;
      LAR2  ; //set address pointer 2 to the start of org send data
      LAR1  ; //add 8 bytes to
      +AR1  P#8.0; //set address pointer 1 to the header of the org. message in subscriber object
      CDB   ; //this command makes it is possible to have the same processing of the subscriber object as
//the processing of the data object (message can be copied from DI to communication DB)
//check send flag
//=> if send flag is false then delete all reservations of this object in all communication DBs

      A     DIX [AR2,P#6.0]; //IF send flag is set
      JC    Con1; //THEN normal processing

//make connection status flag topical	//ELSE do special function => cancel the own reservation

      OPN   DB [#CurrentComDB];
      AN    DBX    2.0;
      =     DIX [AR2,P#5.0];

//delete current reservation of subscriber object in ComDB only when it is the own reservation

      L     W#16#7FFF;
      L     DBW   42;
      <>I   ;
      JC    BEND;
      L     0;
      T     DBW   42;
      JU    BEND;

//calculate current message length of subscriber object message

Con1: L     "BasicData".MessageLength; //entry is done by FC BasicTasks
      T     #CurrentMessageLength; //no. of bytes to send

      JU    P2;

//message is a data object message

//set address pointer

DaOb: L     DILG; //(object DI is already open)
      +     L#-16;
      SLD   3;
      LAR2  ; //set address to start of data object management 16 bytes ahead

//check ST7 code before continueing

      L     DIB [AR2,P#14.0];
      L     B#16#A5;
      <>I   ;
      JCN   Di01;

      L     W#16#B10D;
      T     "BasicData".EventID;
      L     DINO;
      T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;

      UC    "Diagnose";
      JU    BEND; //end after sending the message

//special function: check send flag
//=> if send flag is not set then delete all reservations of this object in all communication DBs

Di01: A     DIX [AR2,P#6.0]; //IF send flag is set
      JC    Con2; //THEN continue because no special function is required
      L     DINO;
      T     #TempBuffer; //load current object no.
      JU    SpFc; //ELSE enter the special function for delete all current reservations

//calculate the current message length and enter it into the data object message header
//this length is only valid when it is a message to one subscribers. If the message is to all other subscribers,
//then the length has to be corrected by subtracting 4 bytes of the header, because the message has no destination address

Con2: L     DIW [AR2,P#2.0]; //start address of messge in the data object
      SLD   3;
      T     #TempBuffer; //store start of message for the case of the entry into the send buffer
      LAR1  ;

      AN    DIX [AR1,P#3.4]; //IF message should not send with time stamp (Z)
      L     16; //message length: head length + source/destination
      JC    Mes1;

      L     24; //ELSE message length: head length + length time stamp + source/destination
Mes1: L     DIB [AR2,P#4.0]; //no of bytes to send
      +I    ;

      AN    DIX [AR1,P#3.7]; //IF TA = 0 / 1
      =     #OrgData;
      JCN   Ok02; //THEN calculated message is a data message and message length is ok
      L     4; //else it is an org. message => add 4 bytes for org. segment length and rel. obj. no.
      +I    ;

Ok02: T     DIB [AR1,P#0.0]; //enter message length into the message header
      T     #CurrentMessageLength;

//enter current no. of destination partner into message header

      L     DIB [AR1,P#5.0];
      L     DIB [AR2,P#1.0];
      SLW   4;
      OW    ;
      T     DIB [AR1,P#5.0];

//check whether it is a message to all other subscribers

      L     0;
      L     DIB [AR2,P#1.0]; //IF no. of destination subscriber is not 0
      ==I   ;
      =     #MessageToAll; //the flag displays, that the message should be send to all partners
      JC    MTA; //THEN message to all

//load current communication DB no.

      L     L#-16; //if 1 partner exists then set address pointer2 back for 2 bytes (after SLD3)
      +AR2  ;
      L     DIW [AR2,P#0.0]; //start address of the partner subscriber in subscriber object list
      +     L#2; //buffer of start address of connection description
      SLD   3;
      LAR1  ;
      OPN   "BasicData";
      L     DBW [AR1,P#0.0]; //pointer to the current communication DB in the connection description
      SLD   3;
      LAR1  ;
      L     DBW [AR1,P#0.0]; //load current communication DB no.
      T     #CurrentComDB;
      LAR1  #TempBuffer; //restore address pointer 1 to start of message in data object
      +AR2  P#2.0; //restore address pointer 2 to start of data object management again

      JU    P2;

MTA:  R     #WaitForEntry; //preset flag. It will be set when a entry into any send buffer is blocked momentarily

//calkulate and enter current message length (no. of destination subscriber is 0 => message header has no destination address)

      L     #CurrentMessageLength;
      +     -4; //message length is 4 bytes shorter because
      T     #CurrentMessageLength; //destination subscriber no. and destination object no. does not exist
      T     DIB [AR1,P#0.0];

//enter no. of destination subscriber (= 0) into the message header of the process data object

      L     DIB [AR1,P#5.0];
      L     B#16#F;
      AW    ;
      T     DIB [AR1,P#5.0];

//check whether the current message can be entered in all communication buffers

      L     "BasicData".StartConnectionDescrList; //load start address of the current connection description
      L     "BasicData".ConnectionDescrLength;
      -D    ;
      SLD   3;
      T     #TempPointer1; //preset pointer for the loop 1
      T     #TempPointer3; //preset pointer for the loop 3

//loop over all connection descripions

//check whether all connections are disturbed

      SET   ; //only when all connections are disturbed, then connection status is also distubed
      R     #ConnectionStatus; //so => pre setting bevore loop over all communication DBs is "0"

      L     "BasicData".NofConnectionDescription; //load the number of connection descriptions
LP1:  T     #LoopCounter1;

//load communication DB no.

      L     #TempPointer1;
      L     "BasicData".ConnectionDescrLength;
      SLD   3;
      +D    ;
      T     #TempPointer1;
      L     DBW [#TempPointer1]; //load communication DB no.
      T     #CurrentComDB;

      OPN   DB [#CurrentComDB]; //open the communication DB

//check connection status flag of current ComDB

      A     DBX    2.0; //IF any connection is ok connection status also ok. Only
      S     #ConnectionStatus; //when all connections are disturbed, then connection status is also distubed

//check the reservation

      L     DINO; //IF own reservation for send is existing
      L     DBW   42;
      ==I   ;
      JC    ChSp; //THEN check space for entry into send buffer

      L     0; //IF no reservation is existing and
      ==I   ;
      A     DBX    2.0; //and the connection is ok
      JC    Res; //THEN do the reservation

      A     DBX    2.0; //IF connection status is ok, but reservation was not possible
      S     #WaitForEntry; //THEN set wait for entry flag and
      JC    GoOn; //go on with next loop

      L     DBW   42; //IF reservation is not possible
      L     0;
      ==I   ;
      JCN   GoOn; //THEN go on with next loop
//ELSE do the reservation anyway,
      L     DINO; //because any problem with the send buffer entry could be passed
      T     DBW   42; // after the wait flag has been gone and it was a XPDU
      JU    GoOn; //execute next loop

//enter the object no. to the reservation buffer of the communication buffer

Res:  L     DINO;
      T     DBW   42;

//check whether the entry of message into the communication DB is possible

ChSp: L     DBW   22; //IF there is too less free buffer for a entry
      L     DBW   24; //in this send buffer
      +D    ;
      L     DBW   26;
      -D    ;
      L     #CurrentMessageLength;
      <I    ;
      S     #WaitForEntry; //THEN wait for entry at the moment

//check whether any more communication DBs are to check

GoOn: L     #LoopCounter1;
      LOOP  LP1; //check next communication DB

//set connection error flag when all connections are disturbed

      AN    #ConnectionStatus;
      =     DIX [AR2,P#5.0];

//check whether to wait for any entry

      A     #WaitForEntry; //IF any send buffer is not ready for entry
      JC    BEND; //THEN wait for

//reset send flag of data object

      R     DIX [AR2,P#6.0];

//copy the data loss flag into the message header and reset it in the data object management

      A     DIX [AR2,P#7.0]; //copy data loss flag of management
      =     DIX [AR1,P#4.7]; //to data loss flag in message header
      R     DIX [AR2,P#7.0];

//enter the current message in all communication buffers that are ok (if a send buffer is not ok an entry
//will happen anyway when the message is not a XPDU and there is enought free send buffer available)

//loop over all connection descripions again for entering the current message into all send buffers

      L     "BasicData".NofConnectionDescription; //load the number of connection descriptions
LP3:  T     #LoopCounter1;

//load next communication DB no.

      L     #TempPointer3;
      L     "BasicData".ConnectionDescrLength;
      SLD   3;
      +D    ;
      T     #TempPointer3;
      L     DBW [#TempPointer3]; //load communication DB no.
      T     #CurrentComDB;

//check the reservation

      OPN   DB [#CurrentComDB]; //open the communication DB
      L     DINO; //IF it is not the own reservation
      L     DBW   42;
      ==I   ;
      JCN   Subs; //THEN set data loss flag in all Subscriber objects which are connected with this send buffer

      L     0;
      T     DBW   42; //ELSE check out the reservation

//check whether the entry of message into the communication DB is possible

      L     DBW   22; //IF there is too less free buffer for a entry
      L     DBW   24; //in this send buffer
      +D    ;
      L     DBW   26;
      -D    ;
      L     #CurrentMessageLength;
      <I    ;
      JC    Subs; //THEN set data loss flag in all Subscriber objects which are connected with this send buffer

//set source and destination pointer for to enter the message into the send buffer

      L     DBW   26;
      SLD   3;
      LAR1  ; //set address buffer 1 to next free byte address in send buffer

      LAR2  #TempBuffer; //set address buffer 2 to start of message

      A     DBX    2.0; //IF connection status is ok
      JC    Cal1; //THEN call subroutine 1 to enter the message in send buffer

      A     DIX [AR2,P#2.4]; //IF the message is a XPDU
      JC    Subs; //THEN set data loss flag in all Subscriber objects which are connected
//with this send buffer
      JU    Cal1; //ELSE call subroutine 1 to enter the message in send buffer

//after executing the subroutine 1 program returns to lable "Next"
//to check whether any more communication DBs are existing

//the following routine ///////////////////////////////////////////////////////////////////////////////////////////////
//sets the data loss flag in all Subscriber objects which are corresponding with the current send buffer

Subs: L     "BasicData".StartSubscrObjList; //set pointer to current connection description address
      +     L#2;
      SLD   3;
      T     #TempPointer2;

      L     "BasicData".NofSubscrObjects;
LP2:  T     #LoopCounter2;

      L     DBW [#TempPointer2]; //load the connection description address of current subscr.
      SLD   3;
      L     #TempPointer3; //IF current connection descr.address is not the connection descr.
      <>D   ; //address of current subscríber object
      JC    NeSu; //THEN look at the next subscriber

//set data loss flag in subscriber object

      L     "BasicData".OffsetSendOrgIndex0;
      +     -2;
      SLD   3;
      L     #TempPointer2;
      +D    ;
      LAR1  ; //address of send org. index 0 in subscriber object
      SET   ;
      S     DBX [AR1,P#3.3]; //data loss flag

//check whether all subscriber objects are processed

NeSu: L     #TempPointer2; //check next subscriber object
      L     "BasicData".SubscrObjectLength;
      SLD   3;
      +D    ;
      T     #TempPointer2;
      L     #LoopCounter2;
      LOOP  LP2;

//go on with processing the next communication DB
///////////////////////////////////////////////////////////////////////////////////////////////////////////////////

Next: LAR2  #TempBuffer; //restore address pointer 2 to start of message
      L     DIB [AR2,P#0.0]; //restore current message length
      T     #CurrentMessageLength;

      L     #LoopCounter1;
      LOOP  LP3; //enter the current message into the next communication DB

      JU    BEND;

//send a message to 1 destination subscriber

//check connection status of current ComDB and make connection status flag topical

P2:   OPN   DB [#CurrentComDB];
      AN    DBX    2.0;
      =     DIX [AR2,P#5.0];

//search for destination subscriber object address

      L     DIW [AR1,P#6.0]; //address of destination subscriber in subscriber object list
      SLD   16;
      T     #TempBuffer;

      CALL "Search" (
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #TempBuffer,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #SubscrAddress);

//restore DB register

      OPN   DB [#CurrentComDB];

//check whether the message is a XPDU

      A     DIX [AR1,P#2.4];
      JC    XP01; //current message is a XPDU of data object or a XPDU of a subscriber object

//check whether a reservation exists

XP02: OPN   DB [#CurrentComDB];
      L     0;
      L     DBW   42;
      ==I   ; //IF no reservation exists
      JC    Free; //THEN do the reservation

      L     DIW [AR1,P#10.0]; //IF it is the own reservation
      ==I   ;
      JC    Chec; //THEN check whether the entry is possible
      JU    BEND; //ELSE end

//do the reservation for current object

Free: L     DIW [AR1,P#10.0]; //enter own (source) object no.
      T     DBW   42;

//check whether the entry of the message into the communication DB is possible

Chec: L     DBW   22; //IF there is too less free buffer for a entry
      L     DBW   24; //in this send buffer (calculate last byte of send buffer
      +D    ;
      L     DBW   26; //subtracting current next free byte addresss
      -D    ;
      L     #CurrentMessageLength; //IF it is not larger then the current message length
      <I    ;
      JC    BEND; //THEN no entry is possible => end

//entering the the message into send buffer is possible

      TAR1  #TempBuffer; //store address pointer 1 (start of message header in DI)

//reset send flag in ComDB and BasicData

      L     DBW    4; //set address pointer 1 to start of org. send data for FC Create
      SLD   3;
      LAR1  ;
      SET   ;
      R     DBX [AR1,P#6.0]; //reset send flag in ComDB
      R     DIX [AR2,P#6.0]; //reset send flag in BasicData

//check out the reservation

      L     0;
      T     DBW   42;

//subscriber object ?

      A     #SubscriberObject;
      JC    Sub;

//XPDU ?

      LAR1  #TempBuffer;
      AN    DIX [AR1,P#2.4];
      JC    Proz;

//reset DF or OF flag in data object
//=>	organisational message ?

      A     DIX [AR1,P#3.7]; //IF TA code is 2 or 3
      L     DIW [AR2,P#10.0]; //set address pointer 1 to org. index 0 in data object
      SLD   3;
      LAR1  ;
      JC    Data; //THEN set the DF flag because it is a data message

      R     DIX [AR1,P#3.5]; //ELSE reset OF flag in data object because it is a org. message
      JU    Ent;

Data: R     DIX [AR1,P#3.4]; //reset DF flag in data object because it is a data message
      JU    Ent;

//copy the data loss flag into the message header and reset it in the data object management

Proz: A     DIX [AR2,P#7.0]; //copy data loss flag of management
      =     DIX [AR1,P#4.7]; //to data loss flag in message header
      R     DIX [AR2,P#7.0];
      JU    Ent;

//is message from subscriber object a XPDU ?

Sub:  A     DIX [AR2,P#10.4]; //F2 byte of message header
      JCN   Ent; //IF no XPDU THEN enter the message

//ELSE set OF flag in subscriber management

      L     #SubscrAddress; //set address pointer 1 to send org. management in subscriber object
      L     "BasicData".OffsetSendOrgIndex0;
      +D    ;
      SLD   3;
      LAR1  ;

      SET   ;
      R     DBX [AR1,P#11.4];

//set pointer to enter the message

Ent:  OPN   DB [#CurrentComDB];
      L     DBW   26; //set address pointer 1 to next free byte address in send buffer
      SLD   3;
      LAR1  ;
      LAR2  #TempBuffer; //set address pointer 2 to start of message header in DI
      JU    Cal1;

//message is a XPDU of process data object or subscriber object

XP01: TAR2  #TempPointer3; //restore address pointer 2 for later use (pointer to the begin of data the object management)

//check whether the destination subscriber object is ok

      L     #SubscrAddress; //calculate pointer to receive org. index 0 of current subscriber object
      L     "BasicData".OffsetRcvOrgIndex0;
      +D    ;
      SLD   3;
      LAR2  ; //set pointer to start of receive index 0

      A     DBX [AR2,P#5.0]; //IF destination subscriber is ok
      LAR2  #TempPointer3; //set address pointer 2 to the begin of the data object management

      JC    XP02; //THEN continue with normal processing

//message is a XPDU and the destination subscriber is not ok

      R     DIX [AR2,P#6.0]; //reset send flag

//prepare additional information for diagnose message

      L     DIW [AR1,P#10.0]; //enter object no. for diagnose message
      T     "BasicData".Info1;
      L     DIW [AR1,P#6.0]; //enter destination subscriber no. for diagnose message
      T     "BasicData".Info2;

      OPN   DB [#CurrentComDB]; //open current comDB

//check whether ist is possible to clear the own reservation

      L     DIW [AR1,P#10.0]; //IF it is not the own reservation
      L     DBW   42;
      <>I   ;
      JC    Go06; //THEN the reservation can not be cleared

      L     0; //ELSE clear the own reservation
      T     DBW   42;

Go06: A     #SubscriberObject; //check whether it is an subscriber object
      JC    SuOb;

//set DF or OF flag in data object

      A     DIX [AR1,P#3.7]; //IF TA code is 2 or 3
      L     DIW [AR2,P#10.0]; //load start of org. index 0 in data object
      SLD   3;
      LAR1  ;
      JC    DaMe; //THEN it is a data message

      S     DIX [AR1,P#3.5]; //ELSE it is a org. message: set OF flag in data object

      L     W#16#B146;
      T     "BasicData".EventID; //error 70: org. message failure appeared

      JU    SeMe;

DaMe: S     DIX [AR1,P#3.4]; //set DF flag in data object

      L     W#16#B145;
      T     "BasicData".EventID; //error 69: data message failure appeared

      JU    SeMe;

//clear the own reservation an set OF flag in subscriber object and reset send flag

SuOb: L     #SubscrAddress;
      L     "BasicData".OffsetSendOrgIndex0;
      +D    ;
      SLD   3;
      LAR2  ;
      S     DBX [AR2,P#11.4]; //set OF flag

      L     W#16#B146;
      T     "BasicData".EventID; //error 69 / 70: org. message failure appeared

SeMe: UC    "Diagnose";

      JU    BEND;

//............................................. subroutine 1 ........................................................
//	Used for:			to enter a message from a DI into a DB 							*
//																	*
//	Input parameters are:	TimeStamp			true / false							*
//					MessageToAll			true / false							*
//					CurrentComDB			communication DB 						*
//					CurrentMessageLength 	in byte							*
//					SubscrAddress			in DB BasicData if SubscrObject = true			*
//					AR2 has to point to the start of the message to copy from the DI 			*
//					AR1 has to point to the start of the first destination byte in the DB		*
//																	*
//...................................................................................................................

Cal1: A     DIX [AR2,P#3.4]; //check whether the message has a time stamp
      =     #TimeStamp;
      L     DID [AR2,P#0.0]; //enter the message header (6 bytes)
      T     DBD [AR1,P#0.0];
      L     DIW [AR2,P#4.0];
      T     DBW [AR1,P#4.0];

      AN    #MessageToAll; //check whether it is a message to all, if yes, no destination address exists
      JC    MOne;

      L     "BasicData".OwnSubscrNo; //source partner no.
      OPN   DB [#CurrentComDB];
      T     DBW [AR1,P#6.0];

      L     DID [AR2,P#10.0]; //source object no. and start index no.
      T     DBD [AR1,P#8.0];
      T     #CurrentIndex; //current index of the message

      +AR1  P#12.0; //set address pointer 1 to next free byte in send buffer (add 12 byte)

      L     #CurrentMessageLength; //correction of the remaining bytes of the message to copy into the send buffer
      +     -12;
      T     #CurrentMessageLength;
      JU    Time;

//Message is send only to one destination

MOne: L     DID [AR2,P#6.0]; //enter destination address (partner no. and object no.)
      T     DBD [AR1,P#6.0];
      T     #TempBuffer; //store destination object no.
      L     "BasicData".OwnSubscrNo; //source partner no.
      OPN   DB [#CurrentComDB];
      T     DBW [AR1,P#10.0];
      L     DID [AR2,P#10.0]; //source object no. and start index no.
      T     DBD [AR1,P#12.0];
      T     #CurrentIndex; //current index of the message

      +AR1  P#16.0; //set address buffer 1 to next free byte in send buffer (add 16 byte)

      L     #CurrentMessageLength; //correction of the remaining bytes of the message to copy into the send buffer
      +     -16;
      T     #CurrentMessageLength;

Time: +AR2  P#14.0; //set address buffer 2 to time stamp
      AN    #TimeStamp; //IF message has no time stamp
      JC    NoTi; //THEN continue at lable no time

      L     DID [AR2,P#0.0]; //ELSE enter time stamp in send buffer
      T     DBD [AR1,P#0.0];
      L     DID [AR2,P#4.0];
      T     DBD [AR1,P#4.0];

      +AR1  P#8.0; //add 8 byte to address pointer 1 in send buffer
      +AR2  P#8.0; //add 8 byte to address pointer 2 in data object

//correct the remaining bytes of the message are to be copied into the send buffer

      L     #CurrentMessageLength;
      +     -8;
      T     #CurrentMessageLength;

//check whether datas of a subscriber or of a data object should be send

NoTi: A     #SubscriberObject; //IF it is a subscriber object
      JC    SuDa; //THEN calculate the start address of subscriber object data

      L     DILG; //set address pointer 2 to org. area in data object
      +     L#-16;
      SLD   3;
      LAR2  ;

//check whether current message is a org. message

      A     #OrgData;
      JC    OrgM;

//calculate the start address of data object data (add start index)

      L     DIW [AR2,P#8.0];
      L     #CurrentIndex;
      +I    ;
      SLD   3;
      LAR2  ;

      JU    CoDa;

//message is an org. message of a process / data typical

OrgM: L     DIB [AR2,P#4.0]; //enter block length of org. segment
      +     2;
      OPN   DB [#CurrentComDB];
      T     DBW [AR1,P#0.0];
      +AR1  P#2.0;

//enter relevant object no. (destination object no.)

      L     #TempBuffer;
      OPN   DB [#CurrentComDB];
      T     DBW [AR1,P#0.0];
      +AR1  P#2.0;

//decrement current message length

      L     #CurrentMessageLength;
      +     -4;
      T     #CurrentMessageLength;

//set current address pointer of data object to org. send index 0

      L     DIW [AR2,P#10.0];
      SLD   3;
      LAR2  ;
      JU    CoDa; //copy data

//calculate the start address of data bytes in the subscriber object

SuDa: L     #SubscrAddress;
      L     "BasicData".OffsetSendOrgIndex0;
      +D    ;
      L     #CurrentIndex;
      +D    ;
      SLD   3;
      LAR2  ;

//enter block length of org. segment

      L     "BasicData".NofBytesToTransmit;
      +     2;
      OPN   DB [#CurrentComDB];
      T     DBW [AR1,P#0.0];
      +AR1  P#2.0;

//enter relevant subsriber no. (own subscriber no.)

      L     "BasicData".OwnSubscrNo;
      OPN   DB [#CurrentComDB];
      T     DBW [AR1,P#0.0];
      +AR1  P#2.0;

//decrement current message length

      L     #CurrentMessageLength;
      +     -4;
      T     #CurrentMessageLength;

//copy the data bytes of data object or data bytes of org. index of subscriber object into the send buffer

CoDa: OPN   DB [#CurrentComDB];
      L     #CurrentMessageLength; //remaining no. of bytes to copy
      SRW   1; //remaining no. of words to copy
LP4:  T     #LoopCounter2;
      L     DIW [AR2,P#0.0];
      T     DBW [AR1,P#0.0];
      +AR1  P#2.0; //forwarding the address pointer for 2 bytes
      +AR2  P#2.0;
      L     #LoopCounter2;
      LOOP  LP4;

//restore the address of next free byte in communication buffer

      TAR1  ;
      SRD   3;
      T     DBW   26;

      A     #MessageToAll;
      JC    Next;
      JU    BEND;

//............................................. subroutine 2 ........................................................
//	This special function is used to delete all reservations of an object the send buffer of any communication DB	*
//																	*
//	Input parameters are:	TempBuffer	...	object number which has reservations in any communication DB	*
//																	*
//																	*
//																	*
//...................................................................................................................

//set address pointer 1 to start of the connection description list

SpFc: L     "BasicData".StartConnectionDescrList;
      SLD   3;
      LAR1  ;

//load the loop counter with the no. of connection descriptions

      L     "BasicData".NofConnectionDescription;
Lp5:  T     #LoopCounter1;

//check reservation in current communication DB

      L     DBW [AR1,P#0.0]; //open current communication DB
      T     #CurrentComDB;
      OPN   DB [#CurrentComDB];
      L     #TempBuffer; //IF this object has no reservation in the current communication DB
      L     DBW   42;
      <>I   ;
      JC    Go01; //THEN look at the next communicatio DB

      L     0; //ELSE delete the reservation in the current communication DB
      T     DBW   42;

//check connection status flag of current ComDB

      AN    DBX    2.0;
      =     DIX [AR2,P#5.0];

//set address pointer 1 to the next connection description

Go01: L     "BasicData".ConnectionDescrLength;
      SLD   3;
      +AR1  ;
      L     #LoopCounter1; //check whether any more connection description exists
      LOOP  Lp5;

BEND: A     #SubscriberObject;
      BEC   ;
      L     #CurrentComDB; //replay current ComDB for command- and setpoint message blocks
      T     "BasicData".CurrentComDB;


END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION "BasicTask" : VOID
TITLE =	BasicTsk
//
//
//	This FC is responsible for the central activities of the SINAUT ST7 system
//	It executes the main processing after a system start as well as the processing of all existing communication DB´s
//	Further more it executes the central organization tasks like starting and monitoring of general requests
//	as well as to give a reply after a request etc.
//
//
//Message	Event 	Info1:			Info2:
//no. 		ID´s
//(14) 	B10E	BasicData DB no.	0			no valid subscriber object detected
//(15) 	B10F	SubscrNo		0			in current communication DB required connection type not available
//(16) 	B110	SubscrType 		SubscrNo		detected subscriber type is not permissible
//(81)		B051	SubscrNo		0			subscriber ok
//(81)		B151	SubscrNo		0			subscriber not disturbed
//(96) 	B160	SubscrNo		0			general request is not complete
//(97)		B161	SubscrNo		0			single request is not complete
//(242) 	B1A0 	OwnSubscrNo		0			system initialisation ready
//
//
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : BasicTsk
VERSION : 1.7


VAR_INPUT
  UserFC : INT ;	//no. of FC for a user defined task to process received messages
//current subscrib
END_VAR
VAR_TEMP
  RI0GeneralRequest : BOOL ;	//general request
  RI0SingleRequest : BOOL ;	//single request
  RI0DisableDataTrans : BOOL ;	//disable process data transmission
  RI0EnableDataTrans : BOOL ;	//enable process data transmission
  RI0SpareFlag1_4 : BOOL ;
  RI0CountValueRestoreCmd : BOOL ;	//counter value restorage comand
  RI0SpaceFlag1_6 : BOOL ;
  RI0SpaceFlag1_7 : BOOL ;	//(2)receive index 2 (byte 3) of current subscriber object
  RI2SubscrSystemStarted : BOOL ;	//subsciber system was started
  RI2GeneralRequestStart : BOOL ;	//general request start
  RI2GeneralRequestEnd : BOOL ;	//general request end
  RI2DataLoss : BOOL ;	//date loss occured
  RI2InternalRequestStart : BOOL ;	//display that general request start flag was set internal
  RI2CommandOutputFailure : BOOL ;	//command output failure
  RI2GetCommandControl : BOOL ;	//get command control
  RI2ReleaseCommandControl : BOOL ;	//release command control
//(3)receive index 4 (byte 4) of current subscriber objec
  RI4StatusOfDialUpConn_0 : BOOL ;	//status of dial up connection, bit 0
  RI4StatusOfDialUpConn_1 : BOOL ;	//status of dial up connection, bit 1
  RI4StatusPermConn_0 : BOOL ;	//status of permanent connection, bit 0
  RI4StatusPermConn_1 : BOOL ;	//status of permanent connection, bit 1
  RI4AlteDialConnectSearch : BOOL ;	//searching process for an alternative dialing connection is in progress
  RI4DataTransmInWaitState : BOOL ;	//data transmission in monitoring direction is in wait state
  RI4SpareFlag4_6 : BOOL ;
  RI4SpareFlag4_7 : BOOL ;	//(4)receive index 4 (byte 5) of current subscriber object
  RI4SubscriberOk : BOOL ;	//subscriber is ok
  RI4AllCommPathsOk : BOOL ;	//all communication paths are ok
  RI4CommPathBlocked : BOOL ;	//communication path is blocked
  RI4TIMCurrentDeviceID_0 : BOOL ;	//current device ID of TIM (code flag 0)
  RI4TIMCurrentDeviceID_1 : BOOL ;	//current device ID of TIM (code flag 1)
  RI4PollingModeReleased : BOOL ;	//polling mode is released
  RI4PolledInMainCycle : BOOL ;	//subscriber is polled in main cycle
  RI4ContPollActivated : BOOL ;	//continues polling mode is activated
//(5)receive index 8..12 (byte 11) of current
  RI10FirstSysStart : BOOL ;	//first system start
  RI10DataTransmBlocked : BOOL ;	//data transmission is blocked
  RI10CmdControlBlocked : BOOL ;	//command control is blocked
  RI10RequestError : BOOL ;	//request error occured
  RI10OrgMessageFailure : BOOL ;	//originational message has failed
  RI10SpareFlag11_5 : BOOL ;
  RI10SpareFlag11_6 : BOOL ;
  RI10SpareFlag11_7 : BOOL ;	//(6)send index 0 (byte 0) of current subscriber object
  SI0DisableTimImageMem : BOOL ;	//disable image memory of TIM
  SI0EnableTimImageMem : BOOL ;	//enable image memory of TIM
  SI0SpareFlag0_2 : BOOL ;
  SI0SelectSecondComPath : BOOL ;	//select second communication path
  SI0DeselectSecondComPath : BOOL ;	//deselect second communication path
  SI0DisableIncomingCall : BOOL ;	//disable incoming call
  SI0EnableIncomingCall : BOOL ;	//enable incoming call
  SI0UncondDisconnect : BOOL ;	//unconditional disconnect of a communication path
//(7)send index 0 (byte 1) of cu
  SI0GeneralRequest : BOOL ;	//general request
  SI0SingleRequest : BOOL ;	//single request
  SI0DisableDataTrans : BOOL ;	//disable process data transmission
  SI0EnableDataTrans : BOOL ;	//enable process data transmission
  SI0SpareFlag1_4 : BOOL ;
  SI0CountValueRestoreCmd : BOOL ;	//counter value restorage comand
  SI0DisableWorking : BOOL ;	//disable working of a typical
  SI0EnableWorking : BOOL ;	//enable working of a typical
//(8)send index 2 (byte 2) of current subscriber obje
  SI2BlockCommPath : BOOL ;	//block the communication path
  SI2UnblockCommPath : BOOL ;	//unblock the communication path
  SI2LockTelephoneNoList : BOOL ;	//lock the telephone number list
  SI2UnlockTelephoneNoList : BOOL ;	//unlock the telephone number list
  SI2ActivatePermConnect : BOOL ;	//aktivate a permanent connection
  SI2DeactivatePermConnect : BOOL ;	//deaktivate a permanent connection
  SI2PollInMainCycle : BOOL ;	//poll subscriber in main cycle
  SI2PollInSubCycle : BOOL ;	//poll subscriber in sub cycle
//(9)send index 2 (byte 3) of current subscriber obj
  SI2SubscrSystemStarted : BOOL ;	//subsciber system was started
  SI2GeneralRequestStart : BOOL ;	//general request start
  SI2GeneralRequestEnd : BOOL ;	//general request end
  SI2DataLoss : BOOL ;	//date loss occured
  SI2AckOfFirstSysStart : BOOL ;	//acknowledge of first system start
  SI2CommandOutputFailure : BOOL ;	//command output failure
  SI2GetCommandControl : BOOL ;	//get command control
  SI2ReleaseCommandControl : BOOL ;	//release command control
//(10)send index 4 (byte 4) of current subscriber object
  SI4CompFlSubscrOk : BOOL ;	//compare flag for Subscriber ok
  SI4TriggerByChange : BOOL ;	//trigger to send when status in subscriber object changed
  SI4TriggerByGeneralReq : BOOL ;	//trigger to send by initialisation of a general request
  SI4TriggerBySingleReq : BOOL ;	//trigger to send by initialisation of a single request
  SI4CompFlDataTransDisabl : BOOL ;	//compare flag for data transmission disabled
  SI4CompFlOrgMessFailed : BOOL ;	//compare flag for organisational message has failed (OF)
  SI4SpareFlag4_6 : BOOL ;
  SI4SpareFlag4_7 : BOOL ;	//(11)send index 4 (byte 5) of current subscriber object
  SI4GeneralRequestActive : BOOL ;	//general request is active
  SI4SingleRequestActive : BOOL ;	//single request is active
  SI4GenReqStartReceived : BOOL ;	//start of general request was received
  SI4GenReqIncomplete : BOOL ;	//general request was incomplete
  SI4Index4and6Expected : BOOL ;	//receiving of index 4 + 6 expected
  SI4Index8_to_12Expected : BOOL ;	//receiving of index 8 .. 12 expected
  SI4GenerateReqEndMessage : BOOL ;	//generate the request end message when it is ST1 protocol
  SI4SendGenReqEndMessage : BOOL ;	//send general request end message
//(12)send index 8 .. 12 (byte 11) of current s
  SI10FirstSysStart : BOOL ;	//first system start
  SI10DataTransmBlocked : BOOL ;	//data transmission is blocked
  SI10CmdControlBlocked : BOOL ;	//command control is blocked
  SI10RequestError : BOOL ;	//request error occured
  SI10OrgMessageFailure : BOOL ;	//originational message has failed
  SI10SpareFlag11_5 : BOOL ;
  SI10SpareFlag11_6 : BOOL ;
  SI10SpareFlag11_7 : BOOL ;	//local program control variable
  CurrentSystemTime : TIME ;	//used for ret_val of SFC TIME_TCK
  RemainingNofSubscrObj : INT ;	//loop counter
  RemainingNofConnectDescr : INT ;	//loop counter
  PointerToCurrSubscrObj : DWORD ;
  PointerToCurrSendOrgInd0 : DWORD ;
  PointerToCurrRcvOrgInd0 : DWORD ;
  PointerToBasicCreaData : DWORD ;
  PointerToCommDBCreaData : DWORD ;
  PointerToCurrConnectDesc : DWORD ;
  TempBuffer : INT ;
  TempComDB : INT ;
  X_NX_Buffer : WORD ;
  NofSubscrObject : INT ;
  Premiere : BOOL ;
  IndicatorFlag : BOOL ;
  TimeStamp : BOOL ;	//true after system start when FC Time is loaded
  LocalTimConnectDetected : BOOL ;	//true, when a connection to a local TIM is detected and status of connect is ok
  ST1 : BOOL ;	//flag is used for general requests with FA-flag = 0 for ST1 systems
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!

RUN:  NOP   0;
NETWORK
TITLE =
//general section *********************************************************************************************************************
//
//check whether a diagnose message has to send because there are no subscriber objects detected
      L     0;
      L     "BasicData".NofSubscrObjects;
      >=I   ;
      AN    "BasicData".NoSubscrObjectDetected;
      S     "BasicData".NoSubscrObjectDetected;
      R     "BasicData".SystemStart; //no system start is permissible
      R     "BasicData".SystemStartEdgeFlag;
      JCN   Di01;

      L     DBNO;
      T     "BasicData".Info1;
      L     W#16#B10E; //error 237: "no valid subscriber object detected"
      T     "BasicData".EventID;
      L     0;
      T     "BasicData".Info2;

      UC    "Diagnose"; //if no valid subscriber object detected, send a diagnose message and end
      JU    BEND;

//check whether the program should be aborted

Di01: L     0; //IF no subscriber objects are detected
      <=I   ;
      BEC   ; //THEN the tasks will be canceled
      R     "BasicData".NoSubscrObjectDetected;

//detecting system initalisation

      >I    ; //IF the no. of subscriber objects is > 0
      AN    "BasicData".SystemInitialFlag; //AND it was not detected before
      S     "BasicData".SystemInitialFlag; //THEN set system flag for initialisation
      JCN   NoIn; //ELSE no additional initialisation is necessary

      S     "BasicData".SystemStart; //set system start flag to do the initialisation
      S     #Premiere; //set premiere flag to display that it is the first system start

//detecting end of system start

NoIn: A     "BasicData".SystemStart; //IF system start flag is detected after 1 complete cycle
      A     "BasicData".SystemStartEdgeFlag; //THEN trigger system start message to all communication partners
      R     "BasicData".SystemStart;
      R     "BasicData".SystemStartEdgeFlag;
      JCN   GR; //ELSE check general request

//send diagnose message "system initialisation ready

      L     W#16#B1A0; //ID of "system initialisation ready"
      T     "BasicData".EventID;
      L     "BasicData".OwnSubscrNo;
      T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;

      UC    "Diagnose"; //call function to send the diagnose message

      L     "BasicData".StartSubscrObjList; //set address pointer 1 to start of current send org. index
      L     "BasicData".OffsetSendOrgIndex0;
      +D    ;
      SLD   3;
      T     #PointerToCurrSendOrgInd0;
      LAR1  ;

//trigger message "subscriber started" to all partner

      L     "BasicData".NofSubscrObjects;
Lo00: T     #RemainingNofSubscrObj;

//set system start / status changed / subsribers 1st system start flag in org send index,

      SET   ;
      S     DBX [AR1,P#3.0]; //set flag "subsriber started"
      L     #PointerToCurrSendOrgInd0; //calculate new pointer to send org index buffer of next subscriber object
      L     "BasicData".SubscrObjectLength;
      SLD   3;
      +D    ;
      T     #PointerToCurrSendOrgInd0;
      LAR1  ;

      L     #RemainingNofSubscrObj;
      LOOP  Lo00;

//detecting system start (system initialisation runs whenever system start flag is detected)

GR:   A     "BasicData".SystemStart; //system start is detected and system start not running yet
      AN    "BasicData".SystemStartEdgeFlag;
      S     "BasicData".SystemStartEdgeFlag; //set system start is running yet (edge flag)
      JCN   CyPr;

//calculate the start address of the connection description

      L     "BasicData".SubscrObjectLength;
      L     "BasicData".NofSubscrObjects;
      *D    ;
      L     "BasicData".StartSubscrObjList;
      +D    ;
      T     "BasicData".StartConnectionDescrList;

//enter user FC number for individual processing of received messages

      L     #UserFC;
      T     "BasicData".FC_User;

//reset current date/time, last sync. date/time and current ComDB

      L     0;
      T     DBD    0;
      T     DBD    4;
      T     DBD    8;
      T     DBD   12;
      T     DBW   16;
      T     "BasicData".CurrentComDB;

//reset the whole area from start of system flags till start of subscriber objects

//calculate start address of erasing area

      L     "BasicData".StartSystemFlags; //start address of destination bytes
      +     1; //is the 2 nd system flag byte
      SLD   3; //the 1 st system flag byte is remanent and should be not deleted
      LAR1  ;

//reset data bytes of all subscriber objects
//calculate the no. of bytes to erase

      L     "BasicData".StartSubscrObjList;
      L     "BasicData".StartSystemFlags;
      -D    ;
      +     -1; //caution! first system flag byte is remanent
Res0: T     #TempBuffer;
      L     0;
      T     DBB [AR1,P#0.0];
      +AR1  P#1.0;
      L     #TempBuffer;
      LOOP  Res0;

      L     "BasicData".StartSubscrObjList; //set address pointer1 to start of subscriber object list
      SLD   3;
      LAR1  ;
      T     #PointerToCurrSubscrObj;

      L     "BasicData".NofSubscrObjects;
Lo01: T     #RemainingNofSubscrObj;

//enter the address of the current connection description into current subscriber object

      L     DBW [AR1,P#0.0]; //load subsriber no. for later use
      T     #NofSubscrObject;

      L     DBW [AR1,P#4.0]; //no. of current connection descriptions
      +     L#-1;
      L     "BasicData".ConnectionDescrLength;
      *D    ;
      L     "BasicData".StartConnectionDescrList;
      +D    ;
      T     DBW [AR1,P#2.0];

//enter current subscriber address of local partner

      SLD   3;
      LAR1  ;
      L     DBW [AR1,P#6.0]; //IF subscriber no. in current connection description
      L     #NofSubscrObject; //is equal with current subscriber no.
      <>I   ;
      JC    M001;

      L     #PointerToCurrSubscrObj; //THEN enter current subscriber address to current connection description
      SRD   3;
      T     DBW [AR1,P#8.0];

//set address pointer 2 to start of deleting area in subscriber object

M001: LAR1  #PointerToCurrSubscrObj;
      TAR1  AR2;
      +AR2  P#10.0;

//erase an specified array in every subscriber object

      L     "BasicData".SubscrObjectLength; //calculate length of area in DWs which are to be deleted
      +     -10;
      SRW   1; //calculate no. of words
      T     #TempBuffer;

//delete array in subscriber object

Res1: T     #TempBuffer;
      L     0;
      T     DBW [AR2,P#0.0];
      +AR2  P#2.0;
      L     #TempBuffer;
      LOOP  Res1;

//foreward the address pointer1 to next subscriber object

      TAR1  ;
      L     "BasicData".SubscrObjectLength;
      SLD   3;
      +D    ;
      T     #PointerToCurrSubscrObj;
      LAR1  ;

      L     #RemainingNofSubscrObj;
      LOOP  Lo01;

//preparing the system time

      CALL "TIME_TCK" (
           RET_VAL                  := "BasicData".LastSystemTime);//preset the system time

//cyclic programm

//common section: calculate last OB1 cycle time

CyPr: CALL "TIME_TCK" (//calculate last cycle time
           RET_VAL                  := #CurrentSystemTime);

//calculate last OB1 cycle time

      L     #CurrentSystemTime;
      L     "BasicData".LastSystemTime;
      >=D   ;
      JC    Pos; //the cycle time always must be positive
      TAK   ;
Pos:  -D    ;
      T     "BasicData".LastOB1CycleTime;

      L     #CurrentSystemTime;
      T     "BasicData".LastSystemTime;

//command monitoring 1 of n

      SET   ;
      R     "BasicData".CmdOut_1ofNCheckReq;

      A     "BasicData".CmdOut_1ofNError;
      AN    "BasicData".CmdOut_1ofNCheckReq;
      R     "BasicData".CmdOut_1ofNError;

//section 1: evaluation of the last received message for all subscriber objects *******************************************************

//prepare loop over all subscribers

      L     "BasicData".StartSubscrObjList; //calculate the start of current subscriber object
      SLD   3;
      T     #PointerToCurrSubscrObj;

      L     "BasicData".OffsetRcvOrgIndex0; //calculate start of receive index 0 in current subscriber object
      SLD   3;
      +D    ;
      T     #PointerToCurrRcvOrgInd0;

      L     #PointerToCurrSubscrObj;
      L     "BasicData".OffsetSendOrgIndex0; //calculate start of send index 0 in current subscriber object
      SLD   3;
      +D    ;
      T     #PointerToCurrSendOrgInd0;

//loop over all subscriber objects

      L     "BasicData".NofSubscrObjects;
Lo02: T     #RemainingNofSubscrObj;

//load current subscriber org. index into local index buffer

      LAR2  P##RI0GeneralRequest; //start of local index array

      LAR1  #PointerToCurrRcvOrgInd0;
      L     DBB [AR1,P#1.0]; //load receive index 0, byte 1
      T     LB [AR2,P#0.0];

      L     DBB [AR1,P#3.0]; //load receive index 2, byte 3
      T     LB [AR2,P#1.0];

      L     DBW [AR1,P#4.0]; //load receive index 4, byte 4 and byte 5
      T     LW [AR2,P#2.0];

      L     DBB [AR1,P#11.0]; //load receive index 8, byte 11
      T     LB [AR2,P#4.0];

      LAR1  #PointerToCurrSendOrgInd0;
      L     DBD [AR1,P#0.0]; //load send index 0 amd 2 complete
      T     LD [AR2,P#5.0];

      L     DBW [AR1,P#4.0]; //load send index 4, byte 4 and byte 5
      T     LW [AR2,P#9.0];

      L     DBB [AR1,P#11.0]; //load send index 8, byte 11
      T     LB [AR2,P#11.0];

      LAR1  #PointerToCurrSubscrObj; //set address pointer 1 to start of current subscriber object

//processing of last received originational message

//check no. of received bytes

      L     0;
      L     DBB [AR1,P#16.0]; //IF no. of received bytes is 0
      ==I   ;
      JC    A; //THEN continue at lable "A"

//set no. of received bytes to 0

      L     0;
      T     DBB [AR1,P#16.0];

//check whether it was a requested organizational message

      A     DBX [AR1,P#18.6]; //IF it was NO requested organizational message (TA code = 1)
      AN    DBX [AR1,P#18.7];
      JCN   A; //THEN ready

//check whether the start index is 4 or 8

      L     4; //IF start index of last received message is not 4
      L     DBW [AR1,P#24.0];
      <>I   ;
      JC    ChI8; //THEN check whether start index was 8

      R     #SI4Index4and6Expected; //ELSE reset flag "waiting for start index 4"
      L     DBW [AR1,P#20.0]; //copy the source subscriber no. to buffer "subscr. no. of the local TIM"
      T     DBW [AR1,P#12.0];
      JU    A;

ChI8: L     8; //IF start index is not 8
      <>I   ;
      JC    A; //THEN ready

      R     #SI4Index8_to_12Expected; //ELSE reset flag "waiting for start index 8"

A:    A     #RI0GeneralRequest; //IF flag "general request" in receive index 0 is true
      A     "BasicData".DelayGenReqEnd; //and message "general request end" should be delayed
      S     #SI4SendGenReqEndMessage; //THEN set help flag "general request end is delayed"
      R     #RI0GeneralRequest;

      O     #RI0GeneralRequest; //IF flag "general request" in receive index 0 is true
      O     #SI4SendGenReqEndMessage; //or general request end message was delayed
      AN    "BasicData".DelayGenReqEnd; //and message general request end should not be delayed any longer
      R     "BasicData".GeneralRequest; //THEN  reset also global general request flag
      S     #SI2GeneralRequestEnd; //send "general request end message"
      R     #SI4SendGenReqEndMessage; //reset help flag "general request end is delayed"

      SET   ;
      R     "BasicData".DelayGenReqEnd; //reset delay flag "general request end message" every cycle
      R     "BasicData".CounterValueStorage; //reset counter command because of ST1 command only the global flag is set

      L     0; //reset receive index 0 completely
      T     LB [AR2,P#0.0]; //delete receive index 0, byte 1

//reset receive index 2 completely

//store flag "subscriber is ok" in send index 4 and send a diagnose message when status changed

      A     #RI4SubscriberOk; //IF flag "subscriber ok" in receive index 4
      AN    #SI4CompFlSubscrOk; //AND last cycle it was false
      S     #SI4CompFlSubscrOk; //store it to a compare flag in send index 4
      L     W#16#B051;
      JC    Diag; //THEN send a diagnose message

      AN    #RI4SubscriberOk; //IF flag "subscriber not ok" in receive index 4
      A     #SI4CompFlSubscrOk; //AND last cycle it was true
      R     #SI4CompFlSubscrOk; //store it to a compare flag in send index 4
      L     W#16#B151;
      JC    Diag; //THEN send a diagnose message

      JU    NoMe; //ELSE no message

Diag: T     "BasicData".EventID;
      L     DBW [AR1,P#0.0]; //message info 1 = subscriber no.
      T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;

      UC    "Diagnose";

NoMe: A     #RI4SubscriberOk; //IF flag "subscriber ok" in receive index 4 is true
      =     #SI4CompFlSubscrOk; //THEN store it to a compare flag in send index 4

//store flag "process data blocked" of receive index 8 in send index 4

      A     #RI10DataTransmBlocked; //IF flag "process data blocked" in receive index 10 is true
      =     #SI4CompFlDataTransDisabl; //THEN store it to a compare flag in send index 4

//store command output failure into global system flag

      A     #RI2CommandOutputFailure;
      S     "BasicData".GlobalCmdOutputError;

//check whether the message "end of general request" was received

      AN    #RI2GeneralRequestEnd; //IF "end of general request" was not received
      L     0; //reset receive index 0 completely
      T     LB [AR2,P#1.0]; //delete receive index 2, byte 3
      JC    D; //THEN check whether a general request is still running

//check whether general request end processing is done

      AN    #SI4GeneralRequestActive; //IF general request is not in progress (request end processing is already done)
      JC    E; //THEN check whether a single request is in progress

      R     #SI4GeneralRequestActive; //reset flag general request runs
      R     #SI4GenReqStartReceived; //reset flag general start received

//reset remaining general request monitoring time

      L     0;
      T     DBW [AR1,P#10.0];

//check whether index 4+6 and index 8..12 was received

      O     #SI4Index4and6Expected; //IF index 4+6 were not received
      O     #SI4Index8_to_12Expected; //OR index 8..12 were not received
      S     #SI4GenReqIncomplete; //THEN set flag "general request is not complete"
      R     #SI4Index4and6Expected; //and reset them
      R     #SI4Index8_to_12Expected;

      AN    #SI4GenReqIncomplete; //IF general request is complete
      AN    #SI10RequestError; //AND request error is still true
      JC    E;

//check whether general request is complete

      AN    #SI4GenReqIncomplete; //IF general request is complete
      A     #SI10RequestError; //AND request error is still true
      R     #SI10RequestError; //THEN reset request error and set trigger to send
      S     #SI4TriggerByChange;
      JC    E;

//ELSE set flag "request error" (in index 10) and trigger the message

      A     #SI4GenReqIncomplete; //IF general request is not complete
      A     #SI10RequestError; //AND request error is still true
      R     #SI4GenReqIncomplete; //reset general request is incomplete
      JC    F;

      S     #SI10RequestError; //ELSE set request error
      S     #SI4TriggerByChange; //set trigger to send

//send message: general request is not complete

F:    L     W#16#B160;
      T     "BasicData".EventID;
      L     DBW [AR1,P#0.0]; //message info 1 = subscriber no.
      T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;

      UC    "Diagnose";
      JU    E;

//IF the end message of general request is not received and no request is running

D:    AN    #SI4GeneralRequestActive; //IF general request is not activ
      JC    E; //THEN check single request

//calculate the new remaining general request monitoring time

      AN    "BasicData".Pulse_1s;
      JC    NoDe;

      L     DBW [AR1,P#10.0];
      +     -1;
      T     DBW [AR1,P#10.0]; //=> store new remaining monitoring time of current subscriber

//check whether general request monitoring time is running off

NoDe: L     DBW [AR1,P#10.0];
      L     0;
      >D    ; //IF remaining monitoring time is still running
      A     #RI4SubscriberOk; //and subscriber is ok
      JC    ST1; //THEN check type of subscriber

//ELSE end with processing general request

      AN    #SI4GenReqStartReceived; //IF start of general request was not received
      S     #RI2GeneralRequestStart; //THEN set start of general request was received
      S     #RI2InternalRequestStart; //set flag to remember that request timer should not be started

      A     #SI4GenReqStartReceived; //IF start of general request was not received
      S     #RI2GeneralRequestEnd; //THEN set end of general request was received
      JU    E;

//check type of subscriber and whether a general request was received

ST1:  L     DBB [AR1,P#6.0]; //load subscriber type
      L     2; //IF type of subscriber is not ST1
      <>I   ; //and
      AN    #SI4GenerateReqEndMessage; //the generation of the request end message is not required
      ON    #SI4GenReqStartReceived; //OR general request message was not received
      JC    E; //THEN check single request

//a ST1 evaulation typical is setting the "request is not complete" flag every cycle till the required
//message is received.

      O     #SI4Index4and6Expected; //IF index 4+6 were not received
      O     #SI4Index8_to_12Expected; //OR index 8..12 were not received
      S     #SI4GenReqIncomplete; //THEN set flag "general request is not complete"

//check whether the general request is complete
//(This part reproduces the "request end" which is requirded by a ST7 subscriber because a ST1 subscriber
//does not deliver a general request end message)

      AN    #SI4GenReqIncomplete; //IF general request is complete because no object has set this flag
      S     #RI2GeneralRequestEnd; //THEN display end of general request

      A     #SI4GenReqIncomplete; //IF any ST1 object is missing it´s message after a general request
      R     #SI4GenReqIncomplete; //THEN it will set this flag next cycle again

//check single request

E:    AN    #SI4SingleRequestActive; //IF single request is not running
      JC    NeSu; //THEN next subscriber

      AN    #SI4Index4and6Expected; //IF index 4..12 were received (no more index is expected)
      AN    #SI4Index8_to_12Expected;
      JC    SRS; //THEN single request success

//calculate the new remaining single request monitoring time

      AN    "BasicData".Pulse_1s;
      JC    NDec;

      L     DBW [AR1,P#10.0];
      +     -1;
      T     DBW [AR1,P#10.0]; //=> store new remaining monitoring time of current subscriber

//check whether general request monitoring time is run off

NDec: L     0;
      >D    ; //IF remaining monitoring time is not running off
      A     #RI4SubscriberOk; //and subscriber is still ok
      JC    NeSu; //THEN next subscriber

//ELSE reset flags "index 4..12 were not received"

      R     #SI4Index4and6Expected;
      R     #SI4Index8_to_12Expected;
      R     #SI4SingleRequestActive;

//check request error

      A     #SI10RequestError; //IF request error is already processed
      JC    NeSu; //THEN check next subscriber object

      S     #SI10RequestError; //ELSE set request error and trigger to send
      S     #SI4TriggerByChange;

//send message: single request is not complete

      L     W#16#B161;
      T     "BasicData".EventID;
      L     DBW [AR1,P#0.0]; //message info 1 = subscriber no.
      T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;

      UC    "Diagnose";
      JU    NeSu;

//reset remaining general request monitoring time

SRS:  R     #SI4SingleRequestActive; //reset single request active
      L     0;
      T     DBW [AR1,P#10.0]; //reset monitoring time

//check whether request error is already processed

      A     #SI10RequestError;
      R     #SI10RequestError; //reset request error
      S     #SI4TriggerByChange; //set the trigger to send

//processing the next subscriber object

//save local index buffer to current subscriber object bevore processing next subscriber object

NeSu: LAR1  #PointerToCurrRcvOrgInd0;
      LAR2  P##RI0GeneralRequest; //start of local index array
      L     LB [AR2,P#0.0];
      T     DBB [AR1,P#1.0]; //save receive index 0, byte 1

      L     LB [AR2,P#1.0];
      T     DBB [AR1,P#3.0]; //save receive index 2, byte 3

      L     LW [AR2,P#2.0];
      T     DBW [AR1,P#4.0]; //save receive index 4, byte 4 and byte 5

      L     LB [AR2,P#4.0];
      T     DBB [AR1,P#11.0]; //save receive index 8, byte 11

      LAR1  #PointerToCurrSendOrgInd0;
      L     LD [AR2,P#5.0];
      T     DBD [AR1,P#0.0]; //save send index 0 amd 2 complete

      L     LW [AR2,P#9.0];
      T     DBW [AR1,P#4.0]; //save send index 4, byte 4 and byte 5

      L     LB [AR2,P#11.0];
      T     DBB [AR1,P#11.0]; //save send index 8, byte 11

      L     "BasicData".SubscrObjectLength; //calculate start of receive index 0 in next subscriber object
      SLD   3;
      L     #PointerToCurrRcvOrgInd0;
      +D    ;
      T     #PointerToCurrRcvOrgInd0;

      L     "BasicData".SubscrObjectLength; //calculate start of send index 0 in next subscriber object
      SLD   3;
      L     #PointerToCurrSendOrgInd0;
      +D    ;
      T     #PointerToCurrSendOrgInd0;

      L     "BasicData".SubscrObjectLength; //calculate start address of next subscriber object
      SLD   3;
      L     #PointerToCurrSubscrObj;
      +D    ;
      T     #PointerToCurrSubscrObj;

      L     #RemainingNofSubscrObj;
      LOOP  Lo02;

//Begin of section 2 ******************************************************************************************************************

      L     "BasicData".StartConnectionDescrList;
      SLD   3;
      T     #PointerToCurrConnectDesc;
      LAR1  ;

//look for an local TIM connection with connection status = ok

      SET   ;
      R     #LocalTimConnectDetected;

//loop over all communication DBs for to send and receive messages

//open current communication DB as DI

      L     "BasicData".NofConnectionDescription;
Lo03: T     #RemainingNofConnectDescr;
      L     DBW [AR1,P#0.0];
      T     "BasicData".CurrentComDB;
      T     #TempComDB;

//call the communication DB and set address pointer2 to the begin of DI

      OPN   DI [#TempComDB];
      LAR2  P#DIX 0.0;

//check whether >= 1 local TIM connection with status ok is available (IF not, clock status must be set to false)

      L     DBW [AR1,P#8.0]; //address of local subsciber object
      SLD   3;
      LAR1  ;
      L     DBW [AR1,P#6.0]; //subscriber type of local subscriber
      SRW   7;
      L     W#16#2; //type no. = 1 and remote = 0 => then it is a local TIM
      ==I   ;
      A     DIX [AR2,P#2.0]; //and the connection ok
      S     #LocalTimConnectDetected; //>= 1 valid connection to a TIM founded

      LAR1  #PointerToCurrConnectDesc; //restore address pointer1 to current connection description

//selection of the connection type

      L     DBB [AR1,P#3.0]; //check connection type
      JL    CoEr; //in case of connection type fault
      JU    PPBC; //type = 0: projected programm block communication
      JU    CoEr; //type = 1: projected x communication (not available, only planed)
      JU    NPXC; //type = 2: not projected x communication

//connection type error

CoEr: LAR2  P#DIX 0.0;
      R     DIX [AR2,P#2.0]; //reset connection valid (V) in ComDB
      S     DIX [AR2,P#2.1]; //set connection status changed (VA)

//send diagnoes message: required connection type not available

      L     W#16#B10F;
      T     "BasicData".EventID;
      L     "BasicData".NofConnectionDescription;
      L     #RemainingNofConnectDescr; //calculating of current connection description for message info 1
      -I    ;
      +     1;
      T     "BasicData".Info1; //current connection description
      L     DBW [AR1,P#6.0]; //message info 2 =subscriber no. of local partner
      T     "BasicData".Info2;

      UC    "Diagnose";
      JU    ComE;

//call FB BCom for a projected B-communication

PPBC: UC    "BCom"; //
      JU    ComE; //communication end

//call FB XCom for a non projected X-communication

NPXC: UC    "XCom";

//check whether the connection status has changed

ComE: LAR1  #PointerToCurrConnectDesc; //restore address pointer 1
      LAR2  P#DIX 0.0; //restore address pointer 2
      AN    DIX [AR2,P#2.1]; //IF connection status has not changed
      JC    LEND; //THEN continue at loop end

      R     DIX [AR2,P#2.1]; //ELSE reset the indicator flag "connection status has changed"

//prepare processing of the subscriber objects

      L     DBW [AR1,P#8.0]; //current subscriber address
      L     "BasicData".OffsetRcvOrgIndex0;
      +D    ;
      SLD   3;
      LAR1  ; //set address pointer1 to receive index0 of current subscriber

      A     DIX [AR2,P#2.0]; //connection status ok
      S     DBX [AR1,P#5.0]; //set subscriber ok
      S     DBX [AR1,P#5.1]; //set flag "all connections ok"
      JC    LEND; //go to loop end

//ELSE reset flag "subscriber ok" and "all connections are ok" in all responsible subscriber objects
//which are connected via this communication DB

      L     "BasicData".StartSubscrObjList; //set address pointer1 to start of subscriber object list
      SLD   3;
      T     #PointerToCurrSubscrObj;
      LAR1  ;

      L     #PointerToCurrSubscrObj; //set address pointer2 to start of receive org. index0
      L     "BasicData".OffsetRcvOrgIndex0;
      SLD   3;
      +D    ;
      LAR2  ;

//process all subscriber objects to reset flag "subscriber ok" and flag "all connection ok"

      L     "BasicData".NofSubscrObjects; //set no. of subscriber objects
Lo04: T     #RemainingNofSubscrObj;

      L     #PointerToCurrConnectDesc; //address pointer to current connection description
      SRD   3;
      L     DBW [AR1,P#2.0]; //IF current subscriber object is not corresponding
      <>I   ; //to the same connection description
      JC    Next; //THEN look for the next subscriber

      R     DBX [AR2,P#5.0]; //reset flag "subscriber object is ok"
      R     DBX [AR2,P#5.1]; //reset flag "all connections are ok"

//forewarding the address pointer

Next: L     "BasicData".SubscrObjectLength; //calculate the next subscriber object receive index0
      SLD   3;
      +AR1  ;
      +AR2  ;

      L     #RemainingNofSubscrObj;
      LOOP  Lo04;

//loop end
//set  address pointer1 to next current connection description

LEND: L     #PointerToCurrConnectDesc;
      L     "BasicData".ConnectionDescrLength;
      SLD   3;
      +D    ;
      T     #PointerToCurrConnectDesc;
      LAR1  ;

      L     #RemainingNofConnectDescr;
      LOOP  Lo03; //end of loop over all communication DBs for to send and receive messages

//IF no valid connection to a TIM was detected THEN reset TIM clock ok flag

      AN    #LocalTimConnectDetected; //no valid TIM connection detected
      R     "BasicData".TimClockOk; //reset TIM clock status flag and wait for organisational message 256

//Begin of section 3 ******************************************************************************************************************

//prepare loop over all subscribers

      L     "BasicData".StartSubscrObjList; //calculate the start of current subscriber object
      SLD   3;
      T     #PointerToCurrSubscrObj;

      L     "BasicData".OffsetRcvOrgIndex0; //calculate start of receive index 0 in current subscriber object
      SLD   3;
      +D    ;
      T     #PointerToCurrRcvOrgInd0;

      L     #PointerToCurrSubscrObj;
      L     "BasicData".OffsetSendOrgIndex0; //calculate start of send index 0 in current subscriber object
      SLD   3;
      +D    ;
      T     #PointerToCurrSendOrgInd0;

//check whether all subscribers process data are unblocked

      SET   ; //IF any subscriber is blocked, flag will be set
      R     #IndicatorFlag; //the indicator flag will be checked after loop over all subscribers

//start of the loop over all subscriber objects

      L     "BasicData".NofSubscrObjects;
Lo05: T     #RemainingNofSubscrObj;

      LAR2  P##RI0GeneralRequest; //start of local index array

//load current subscriber org. index into local index buffer

      LAR1  #PointerToCurrRcvOrgInd0;
      L     DBB [AR1,P#1.0]; //load receive index 0, byte 1
      T     LB [AR2,P#0.0];

      L     DBB [AR1,P#3.0]; //load receive index 2, byte 3
      T     LB [AR2,P#1.0];

      L     DBW [AR1,P#4.0]; //load receive index 4, byte 4 and byte 5
      T     LW [AR2,P#2.0];

      L     DBB [AR1,P#11.0]; //load receive index 8, byte 11
      T     LB [AR2,P#4.0];

      LAR1  #PointerToCurrSendOrgInd0;
      L     DBD [AR1,P#0.0]; //load send index 0 amd 2 complete
      T     LD [AR2,P#5.0];

      L     DBW [AR1,P#4.0]; //load send index 4, byte 4 and byte 5
      T     LW [AR2,P#9.0];

      L     DBB [AR1,P#11.0]; //load send index 8, byte 11
      T     LB [AR2,P#11.0];

//check singel request in receive index 0

      AN    #RI0GeneralRequest;
      A     #RI0SingleRequest; //IF singel request was received
      S     #SI4TriggerBySingleReq; //THEN set trigger for single request

//check general request in receive index 0

      A     #RI0GeneralRequest; //IF general request was received
      R     #RI0GeneralRequest; //THEN reset flag general request
      S     #SI2GeneralRequestStart; //set start of general request in send index 2
      R     #SI2GeneralRequestEnd; //reset end of general request in send index 2

//set flag "process data transfer blocked" if corresponding command is received

      A     #RI0DisableDataTrans; //IF process data transfer blocking is required in receive index 0
      S     #SI10DataTransmBlocked; //THEN set flag "process data transfere is blocked" in send index 10
      S     "BasicData".ProcessDataBlocked; //set the global flag
      S     #SI4TriggerByChange; //AND set trigger for sending subscriber object after change

//reset flag "process data transfer blocked" if corresponding command is received

      A     #RI0EnableDataTrans; //IF process data transfer unblock is required in receive index 0
      R     #SI10DataTransmBlocked; //THEN reset flag "process data transfere blocked" in send index 10
      S     #SI4TriggerByChange; //and set trigger for sending subscriber object after change

//check whether any subscribers process data transmissioning is blocked

      A     #SI10DataTransmBlocked; //IF no subscriber with process data transmission blocked will be detected
      S     #IndicatorFlag; //THEN a reset of global flag at the end of the loop can be happen

//set global flag "counted value re-storage" if corresponding command is received

      A     #RI0CountValueRestoreCmd;
      S     "BasicData".CounterValueStorage;

//send command "general request" when subscriber has started

      O     #RI2SubscrSystemStarted; //IF the subscriber has started
      O     #RI2DataLoss; //OR data loss occured
      A     #RI4SubscriberOk; //AND subscriber is ok
      AN    #SI4GeneralRequestActive; //AND no other general request is running
      S     #SI0GeneralRequest; //THEN send command general request in send index 0

//check start of general request

      AN    #RI2GeneralRequestStart; //IF start of general request is received
      JC    B;

      S     #SI4GeneralRequestActive; //THEN set status of general request to activ
      S     #SI4GenReqStartReceived; //store it,
      S     #SI4Index8_to_12Expected; //set flag "index 8..12 expected"

//IF subscriber type is a local subscriber (type value is even)

      A     DBX [AR1,P#7.7]; //IF it is a remote subscriber
      S     #SI4Index4and6Expected; //THEN set flag "index 4+6 expected"

      A     #RI2InternalRequestStart; //IF current request was set internal
      JC    B; //THEN do not start the request timer

      LAR1  #PointerToCurrSubscrObj; //ELSE set address pointer1 to start of current subscriber
      L     DBW [AR1,P#8.0]; //object and start request monitoring time again
      T     DBW [AR1,P#10.0];

//send command "general request" when a change of subscriber status from fault to ok occured

B:    A     #RI4SubscriberOk; //IF status changed to ok
      AN    #SI4CompFlSubscrOk; //THEN send a general request
      S     #SI0GeneralRequest;

//copy receive index 6 to send index 8 when any change occurs

      LAR1  #PointerToCurrRcvOrgInd0;
      LAR2  #PointerToCurrSendOrgInd0;
      L     DBB [AR1,P#6.0];
      L     DBB [AR2,P#8.0];
      ==I   ; //IF no change is detected
      JC    EQ; //THEN send index 8 was already sent

      S     #SI4TriggerByChange; //ELSE set trigger to send
      L     DBB [AR1,P#6.0];
      T     DBB [AR2,P#8.0]; //and copy tbe receive index 6 to send index 8

EQ:   NOP   0;

//Begin of section 4 ******************************************************************************************************************

//clear local X_NX_Buffer generally

      L     0;
      T     #X_NX_Buffer;

      LAR1  #PointerToCurrSubscrObj; //set address pointer1 to start of current subscriber object
      L     DBW [AR1,P#0.0];
      T     #NofSubscrObject; //store own subscriber no. for later use

//open corresponding communication DB

      L     DBW [AR1,P#2.0]; //calculate address pointer of current address of connection description
      SLD   3;
      T     #PointerToCurrConnectDesc; //start of corresponding connection description

      L     DBW [#PointerToCurrConnectDesc];
      T     #TempComDB;
      T     "BasicData".CurrentComDB; //store no. of ComDB to BasicData
      OPN   DI [#TempComDB]; //open current ComDB

//prepare address pointer 1 / 2

      L     "BasicData".StartOrgSendData; //set address pointer1 to start of data for FC Create in DB BasicData
      SLD   3;
      T     #PointerToBasicCreaData;
      LAR1  ;

      L     DIW    4; //set address pointer2 to start of data for FC Create in current Com DB
      SLD   3;
      T     #PointerToCommDBCreaData;
      LAR2  ;

//check send flag in ComDB

      AN    DIX [AR2,P#6.0]; //IF send flag is clear
      JC    SCLR; //THEN clear to send any index is possible

//check whether the last org. message was from own subscriber object

      L     DIW [AR2,P#14.0]; //ELSE check last destination subscriber object no.
      L     #NofSubscrObject; //current subscriber object no.
      ==I   ;
      JCN   NSub; //go on with next subscriber object

//copy data of last org. send message of current subscriber object from communication DB to DB BasicData

      L     15; //copying 15 words
      T     #TempBuffer;

Lo07: T     #TempBuffer;

      L     DIW [AR2,P#0.0];
      T     DBW [AR1,P#0.0];

      +AR1  P#2.0;
      +AR2  P#2.0;
      L     #TempBuffer;
      LOOP  Lo07;

//check current start send index

      L     "BasicData".StartIndexNo;
      L     8; //IF NOT current send index = 8 .. 12
      <>I   ;
      JC    OInd; //THEN it is an other send index

//check whether a trigger flag or a request flag status is true

      O     #SI4TriggerByChange; //IF any trigger flag of index 8...12 is true
      O     #SI4TriggerByGeneralReq;
      O     #SI4TriggerBySingleReq;
      JC    Ind8; //THEN send index 8

//restore the trigger flag in traceing back from the TA code and transmission flags of the message

      L     2#1000110; //filter the TA-code, U and B flags
      L     "BasicData".MessageHeaderFieldF3;
      AW    ;
      L     2#1000000; //IF TA = 1 and U and PR flags are 0
      ==I   ;
      S     #SI4TriggerByGeneralReq; //THEN restore trigger flag "general request"
      JC    Ind8;

      L     "BasicData".MessageHeaderFieldF3;
      SLW   2; //IF TA = 1 (flags U and PR not relevant)
      A     >0;
      S     #SI4TriggerBySingleReq; //THEN restore the single request flag
      JC    Ind8;

      S     #SI4TriggerByChange; //ELSE restore trigger flag "triggered by change"
      L     "BasicData".MessageHeaderFieldF3;
      L     B#16#3F; //TA = 0
      AW    ;
      T     "BasicData".MessageHeaderFieldF3;

      JU    Ind8; //go on processing of index 8



//send flag still is true => check whether there was send index 0 or send index 2 to send


OInd: L     0;
      T     #TempBuffer;

      JU    CLIN; //................call subroutine "CLIN" (clean index)	................................................
//
//	all not permissible bits in local index 0 and 2 will be deleted depending on the subscriber type
//	=>	return from subroutine CLIN will be at lable Ind0 (Return lable 1)
//	=>	address pointer 1 (LAR1) will be set to local variable "SI0DisableTimImageMem" !!!
//
//.....................................................................................................


RET0: LAR2  #PointerToCommDBCreaData; //set address pointer2 to create data in current Com DB

//check current index whether permissible flags are exist

      L     "BasicData".StartIndexNo; //no. of start index of last org. message in ComDB
      L     0; //IF no. of current send index is not 0
      <>I   ;
      JC    INo2; //THEN check whether the no. is 2

//are there any valid flags in send index 0 ?

      L     LW [AR1,P#0.0]; //check whether some flags of send index 0 are true
      ==I   ; //IF no true flags detected
      R     "BasicData".SendFlag0; //THEN reset the send flag in BasicData
      R     DIX [AR2,P#6.0]; //AND reset send flag in ComDB

      JU    Crea; //check out the reservation or try sending the X-PDU again

//check whether there are any valid flags in send index 2

INo2: L     0;
      T     #X_NX_Buffer; //clear buffer
      L     LW [AR1,P#2.0]; //IF no flags of send index 2 are true
      ==I   ;
      R     "BasicData".SendFlag0; //THEN reset the send flag in BasicData
      R     DIX [AR2,P#6.0]; //reset send flag in ComDB
      JC    Crea; //go to create for check out the reservation in ComDB

//ELSE check whether there are X bits and non-X bits existing

      L     W#16#3F; //true flags are "non-X" flags
      L     LW [AR1,P#2.0];
      AW    ;
      T     #X_NX_Buffer; //store "non-X" flags
      L     0;
      <>I   ; //IF "non-X"-flags existing
      SAVE  ; //store status IF "non-X" flags existing

      L     W#16#FFC0; //true flags are "X" flags
      L     LW [AR1,P#2.0];
      AW    ;
      L     0;
      <>I   ;
      A     BR; //AND "non-X"-flags exist
      JC    ChOu; //THEN check out flags before sending the message

//restore the X flag in message header depending on X-flags in index 2

      L     "BasicData".MessageHeaderFieldF2;
      L     B#16#EF; //reset X-flag in message header
      AW    ;
      A     BR; //IF only "non-X"-flags exist
      JC    NonX;

      L     "BasicData".MessageHeaderFieldF2;
      L     B#16#10; //set X-flag in message header
      OW    ;
      T     "BasicData".MessageHeaderFieldF2; //restore X flag in message header
      JU    Crea; //send message
NonX: L     0;
      T     #X_NX_Buffer; //clear "non-X" flags in temp buffer
      JU    Crea; //send message

//check out

ChOu: A     DIX [AR2,P#10.4]; //IF last PDU was a XPDU
      JC    Ente; //"non-X"-flags remaining in X_NX_Buffer, send XPDU

      AN    #RI4SubscriberOk; //IF subscriber is not ok
      JC    DelX; //THEN save "X" flags, send "non-X" flags first

      L     #X_NX_Buffer; //ELSE check out "X" flags (akku1 = non X, akku2 = X)
      TAK   ;
      T     #X_NX_Buffer;
      TAK   ; //send "non-X" flags

      JU    Ente; //enter

DelX: L     #X_NX_Buffer; //transmitt only "non-X" flags, forget "X" flags

//check out "non-X"-flag (non-X flags are buffered in X_NX_Buffer)

Ente: T     LW [AR1,P#2.0]; //Akku1 => local index 2
      JU    Crea;

SCLR: L     0; //set current start index to 0
      T     "BasicData".StartIndexNo;

      L     1;
      T     #TempBuffer;

      JU    CLIN; //................ CALL subroutine "CLIN" (clean index) ...............................................
//
//	all not permissible bits in local index 0 and 2 will be deleted depending on the subscriber type
//	=>	return from subroutine CLIN will be at lable Ind0 (Return lable 1)
//	=>	address pointer 1 (LAR1) will be set to local variable "SI0DisableTimImageMem"
//
//.....................................................................................................

//check contents of index 0, but do not send any index to a SMS master

Ind0: LAR1  P##SI0DisableTimImageMem;

      L     0; //clear buffer
      T     #X_NX_Buffer;

      L     LW [AR1,P#0.0]; //IF any flag of index 0 is true
      ==I   ;
      JCN   Send; //THEN send index 0

//set current send index to 2

SIn2: L     2;
      T     "BasicData".StartIndexNo;

      L     W#16#3F; //load "non-X" flags of index 2 into akku1
      L     LW [AR1,P#2.0];
      AW    ;

//check subscriber status

      AN    #RI4SubscriberOk; //IF subscriber is not ok
      JC    Ind2; //THEN only "non-X" flags are remaining in index 2

//check whether there are X bits and non-X bits existing

      L     W#16#FFC0; //true flags are "X" flags
      L     LW [AR1,P#2.0];
      AW    ;
      T     #X_NX_Buffer; //store "X" flags
      L     0;
      <>I   ; //IF "X"-flags exist
      SAVE  ; //THEN store status => "X"-flags exsisting

      L     W#16#3F; //true flags are "non-X"-flags
      L     LW [AR1,P#2.0];
      AW    ;
      L     0;
      <>I   ; //IF "non-X" flags
      A     BR; //AND "X"-flags existing
      JC    Ind2; //THEN send "non-X" flags at first, X-flags stored in buffer

      L     0;
      T     #X_NX_Buffer; //clear buffer
      L     LW [AR1,P#2.0];

//enter akku1 into the local index 2

Ind2: T     LW [AR1,P#2.0]; //correct local index 2

//check contents of send index 2

      L     0; //IF send index 2 is not 0
      <>I   ;
      JC    Send; //THEN send it

//check type of subscriber => send index8 only to a S7 CPU

Ind8: LAR1  #PointerToCurrSubscrObj;
      L     0;
      L     DBB [AR1,P#6.0]; //IF type of subscriber is a S7 SPU
      ==I   ;
      JC    SeO8; //THEN branch to send ind8

      L     4; //or a ST7cc
      ==I   ;
      JC    SeO8; //THEN branch to send ind8

      R     #SI4TriggerByChange; //ELSE reset all trigger flags
      R     #SI4TriggerByGeneralReq;
      R     #SI4TriggerBySingleReq;
      JU    NSub; //and go to processing next subscriber

SeO8: LAR1  P##SI0DisableTimImageMem;

      L     8;
      T     "BasicData".StartIndexNo; //ELSE check send index 8 .. 12

//check trigger flags

      O     #SI4TriggerByChange; //IF no trigger flag is set
      O     #SI4TriggerByGeneralReq;
      O     #SI4TriggerBySingleReq;
      JCN   NSub; //THEN process next subscriber

//reduce trigger flags to only one trigger

      A     #SI4TriggerByGeneralReq; //max priority has trigger general request
      R     #SI4TriggerBySingleReq;
      R     #SI4TriggerByChange;

      A     #SI4TriggerBySingleReq; //lowest priority has trigger by change
      R     #SI4TriggerByChange;

//prepare message depending of the trigger type
//calculate message length

      AN    "BasicData".SystemStart;
      A     "BasicData".TimeProcessingActive;
      =     #TimeStamp; //create message including time stamp
      L     34; //message length with time stamp
      JC    Time;
      L     26; //message length without time stamp
Time: T     "BasicData".MessageLength;

      L     B#16#C; //set FA =1 and AE = 2
      T     "BasicData".MessageHeaderFieldF1;

      L     0; //set field F2 to 0 => no XPDU because of send index 8
      T     "BasicData".MessageHeaderFieldF2;

      AN    #TimeStamp; //set Z flag
      JC    TiSt;
      L     B#16#10;

//create F3 header of message

TiSt: A     #SI4TriggerByGeneralReq; //TA = 1, U = 0, B = 0
      JC    Greq;

      A     #SI4TriggerBySingleReq; //TA = 1, U = 1, B = 0
      JC    Sreq;

      A     #SI4TriggerByChange; //TA = 0, U = 1, B = 0
      JC    TrCh;

      L     W#16#B1F3;
      T     "BasicData".EventID;
      L     #NofSubscrObject;
      T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;
      CALL "Diagnose" ;
      JU    NSub;

Greq: L     B#16#40; //TA = 1, U = 0, B = 0
      JU    F3;

Sreq: L     B#16#44; //TA = 1, U = 1, B = 0
      JU    F3;

TrCh: L     B#16#4; //TA = 0, U = 1, B = 0

F3:   OW    ;
      T     "BasicData".MessageHeaderFieldF3;

      L     6; //enter no. of bytes to transmit
      T     "BasicData".NofBytesToTransmit;

      JU    Comm; //create common message header fields in BasicData

//create message header fields when send index 0 or send index 2 should be send

Send: L     2; //IF send index is not 2
      L     "BasicData".StartIndexNo;
      ==I   ;
      L     B#16#10;
      T     "BasicData".MessageHeaderFieldF2; //THEN it is a XPDU
      JCN   FA1; //AND FA=1

//enter X flag in message header

      L     W#16#FFC0; //true flags are "X" flags
      L     LW [AR1,P#2.0]; //IF X flags existing in current send index 2
      AW    ;
      L     0;
      <>I   ;
      L     B#16#10; //THEN set X flag
      JC    X;

      L     0; //ELSE reset X flag
X:    T     "BasicData".MessageHeaderFieldF2;

//set FA flag depending on left byte in send index 2

      L     LB [AR1,P#2.0]; //IF any flag in send index 2 left is true
      L     0;
      <>I   ;
      L     B#16#4; //THEN AE=2, FA=0
      JC    FA;

FA1:  O     L [AR1,P#1.0]; //IF general request
      O     L [AR1,P#1.1]; //OR single request
      A     #ST1; //BUT subscriber type is ST1
      L     B#16#4; //THEN AE=2, FA=0 anyway
      JC    FA;

      L     B#16#C; //ELSE AE=2, FA=1

FA:   T     "BasicData".MessageHeaderFieldF1;

//enter current message length in bytes

      AN    "BasicData".SystemStart; //calculate complete message including time stamp
      A     "BasicData".TimeProcessingActive;
      =     #TimeStamp;
      L     30; //complete message length with time stamp
      JC    TimS;
      L     22; //complete message length without time stamp
TimS: T     "BasicData".MessageLength;

      L     2; //enter no. of bytes to transmit
      T     "BasicData".NofBytesToTransmit;

      A     #TimeStamp; //enter message header field 3
      L     B#16#55; //Z=1, TA=1, U=1, PR=1
      JC    Z;
      L     B#16#45; //Z=0, TA=1, U=1, PR=1
Z:    T     "BasicData".MessageHeaderFieldF3;

//only GR start and GR end are transmitted as requested

      O     L [AR1,P#3.1]; //IF index 2: GR start
      O     L [AR1,P#3.2]; //OR index 2: GR end
      JC    Comm; //THEN F3 field is already ok

      L     B#16#3F; //ELSE transmit message with TA=0
      AW    ;
      T     "BasicData".MessageHeaderFieldF3;

Comm: SET   ;
      S     "BasicData".SendFlag0; //set send request
      L     0;
      T     "BasicData".MessageHeaderFieldF4;
      L     B#16#12; //no. of dest. subscr and dest. subscr. address length
      T     "BasicData".NofDestSubscrInMessage;
      L     #NofSubscrObject; //destination subscriber no.
      T     "BasicData".DestinationSubscrNo;
      L     W#16#7FFF;
      T     "BasicData".DestinationObjectNo; //destination object no.
      T     "BasicData".SourceObjectNo; //destination object no.
      L     1;
      T     "BasicData".MaxNofDestSubscr; //max no. of destination subscriber
      T     "BasicData".ParamNofDestSubscr; //no. of destination subscriber which are known of the system
      L     #PointerToCurrSendOrgInd0; //enter address of current send index
      SRD   3;
      L     "BasicData".StartIndexNo;
      +D    ;
      T     "BasicData".StartIndexInSubscrObject;

      AN    #TimeStamp;
      JC    Crea;

      L     "BasicData".CurrentDate; //enter date and time
      T     "BasicData".YearMonthDayHour;
      L     "BasicData".CurrentTime;
      T     "BasicData".MinSecMillisecStatus;

//copy local send index 0,2 and 10 (only the right byte) back to current subscriber index before call FC Create

Crea: LAR1  P##RI0GeneralRequest;
      LAR2  #PointerToCurrSendOrgInd0;

      L     LD [AR1,P#5.0]; //copy back send index 0 amd 2 completely
      T     DBD [AR2,P#0.0];

      L     LB [AR1,P#9.0]; //copy back local send 4 low byte
      T     DBB [AR2,P#4.0];

      L     LB [AR1,P#11.0]; //store send index 10 to subscriber object (byte 11)
      T     DBB [AR2,P#11.0];

      CALL "Create" (
           SubscriberObject         := TRUE);//create a subscriber object message

//restore address pointers and send index 10 from subscriber object

      LAR1  P##RI0GeneralRequest;
      LAR2  #PointerToCurrSendOrgInd0;

      L     DBB [AR2,P#4.0]; //restore local send index 4 low byte
      T     LB [AR1,P#9.0];

      L     DBB [AR2,P#11.0]; //restore local flags send index 10 from subscriber object(byte 11)
      T     LB [AR1,P#11.0];

//check success of the send procedure

      AN    "BasicData".SendFlag0; //IF org. message could be sent (send flag = 0)
      JC    ChIn; //THEN check next index to send

//while message could not be send store back X or non-X flags if buffered

      L     #X_NX_Buffer; //buffer only can be >0 when it was send index 2
      L     DBW [AR2,P#2.0];
      OW    ;
      T     DBW [AR2,P#2.0];

//set address pointer 1 and address pointer 2

      LAR1  #PointerToBasicCreaData;
      LAR2  #PointerToCommDBCreaData;

//copy back create data from BasicData to ComDB

      L     15; //copying 15 words back
      T     #TempBuffer;

Lo08: T     #TempBuffer;

      L     DBW [AR1,P#0.0];
      T     DIW [AR2,P#0.0];

      +AR1  P#2.0;
      +AR2  P#2.0;
      L     #TempBuffer;
      LOOP  Lo08;

      JU    NSub; //go on processing the next subscriber

//check whether org. message was failed

ChIn: A     #SI10OrgMessageFailure; //IF org. message failure apperas
      AN    #SI4CompFlOrgMessFailed;
      S     #SI4TriggerByChange; //THEN send index 8..12 to the partner
      A     #SI10OrgMessageFailure;
      =     #SI4CompFlOrgMessFailed;

//check whether index 0 was sent
      L     0;
      L     "BasicData".StartIndexNo; //IF index 0 was sent
      ==I   ;
      JC    P1; //THEN continue at point 1

//check whether index 2 was sent

      L     2; //IF index 2 was sent
      ==I   ;
      JC    P2; //THEN continue at point 2

      LAR2  #PointerToCommDBCreaData; //ELSE index 8 was sent
      SET   ;
      R     DIX [AR2,P#6.0]; //reset send flag in ComDB
      R     #SI4TriggerByGeneralReq; //reset trigger flags in send index 4
      R     #SI4TriggerBySingleReq;
      R     #SI4TriggerByChange;

      JU    NSub; //go on processing the next subscriber

//check whether the org send index 0 message was successfull

P1:   A     #SI10OrgMessageFailure; //IF org. message could not be send
      JC    ClI0; //THEN clear send index 0

      LAR1  #PointerToCurrSubscrObj;

      AN    #SI0GeneralRequest;
      JC    Go01;

      S     #SI4GeneralRequestActive; //set status of general request to activ
      L     DBW [AR1,P#8.0]; //start request monitoring time
      T     DBW [AR1,P#10.0];

Go01: AN    #SI0SingleRequest;
      JC    ClI0;

      S     #SI4SingleRequestActive; //set status of single request to activ
      S     #SI4Index8_to_12Expected; //set flag "index 8..12 expected"
      L     DBW [AR1,P#8.0]; //start request monitoring time
      T     DBW [AR1,P#10.0];

      A     DBX [AR1,P#7.7]; //IF partner is remote
      S     #SI4Index4and6Expected; //THEN set flag "index 4+6 expected"

ClI0: LAR1  P##SI0DisableTimImageMem; //reset index 0 complete
      L     0;
      T     LW [AR1,P#0.0];

      JU    SIn2; //go to "set current index to 2

//check whether the org send index 2 message was successfull

P2:   A     #SI10OrgMessageFailure; //IF org. message could not be send
      JC    ClI2; //THEN clear send index 2

//check general request start

      AN    #SI2GeneralRequestStart;
      JC    ClI2;

      S     #RI0GeneralRequest; //restore general request in receive index 0
      S     "BasicData".GeneralRequest; //set global general request flag
      S     #SI4TriggerByGeneralReq; //set trigger for send

ClI2: LAR1  P##SI0DisableTimImageMem; //reset index 2 complete
      L     0;
      T     LW [AR1,P#2.0];

//check whether any send flags were stored

      L     0;
      L     #X_NX_Buffer; //IF no flags detected in buffer to send
      ==I   ;
      JC    Ind8; //THEN go to processing send index 8

      T     LW [AR1,P#2.0]; //ELSE restore send index 2
      JU    Send; //and send next send index 2

//save local index buffer to current subscriber object bevore processing next subscriber object

NSub: LAR1  #PointerToCurrRcvOrgInd0;
      LAR2  P##RI0GeneralRequest; //start of local index array
      L     LB [AR2,P#0.0];
      T     DBB [AR1,P#1.0]; //load receive index 0, byte 1

      L     LB [AR2,P#1.0];
      T     DBB [AR1,P#3.0]; //load receive index 2, byte 3

      L     LW [AR2,P#2.0];
      T     DBW [AR1,P#4.0]; //load receive index 4, byte 4 and byte 5

      L     LB [AR2,P#4.0];
      T     DBB [AR1,P#11.0]; //load receive index 8, byte 11

      LAR1  #PointerToCurrSendOrgInd0;
      L     LD [AR2,P#5.0];
      T     DBD [AR1,P#0.0]; //load send index 0 amd 2 complete

      L     LW [AR2,P#9.0];
      T     DBW [AR1,P#4.0]; //load send index 4, byte 4 and byte 5

      L     LB [AR2,P#11.0];
      T     DBB [AR1,P#11.0]; //load send index 8, byte 11

      L     "BasicData".SubscrObjectLength; //calculate start of receive index 0 in next subscriber object
      SLD   3;
      L     #PointerToCurrRcvOrgInd0;
      +D    ;
      T     #PointerToCurrRcvOrgInd0;

      L     "BasicData".SubscrObjectLength; //calculate start of send index 0 in next subscriber object
      SLD   3;
      L     #PointerToCurrSendOrgInd0;
      +D    ;
      T     #PointerToCurrSendOrgInd0;

      L     "BasicData".SubscrObjectLength; //calculate start address of next subscriber object
      SLD   3;
      L     #PointerToCurrSubscrObj;
      +D    ;
      T     #PointerToCurrSubscrObj;

      L     #RemainingNofSubscrObj;
      LOOP  Lo05; //end of the loop over all subscribers


//.............................last section ..........................................................................................

//check indicator flag whether any subscriber object is blocked to send process data messages

      AN    #IndicatorFlag; //IF all subscribers process data were unblocked
      R     "BasicData".ProcessDataBlocked; //THEN reset the global system flag sending process data is blocked

//create PulseFlag_1s (=1 pulse/second only 1 cycle)

      LAR1  P##CurrentSystemTime;
      A     L [AR1,P#2.1];
      AN    "BasicData".Pulse_1sEdgeFlag;
      =     "BasicData".Pulse_1s;
      A     L [AR1,P#2.1];
      =     "BasicData".Pulse_1sEdgeFlag;

      JU    BEND;

//....................................................end main program BasikTask.............................................................


//.....................................................subroutine CLIN.......................................................................
//
//		subroutine CLIN (clean index) cleans all not permissible bits in local index 0 and 2 depending on the subscriber type
//
//					the point of return is specified through variable TempBuffer
//
//...........................................................................................................................................

CLIN: R     #ST1; //previous setting: system family is not ST1
      LAR1  #PointerToCurrSubscrObj; //set address pointer1 to start of current subscriber object
      L     DBW [AR1,P#6.0]; //load subsriber type
      SRW   7;
      JL    NVal;
      JU    Ty0L; //Type 0: ST7 CPU local
      JU    Ty0R; //Type 0: ST7 CPU remote
      JU    Ty1L; //Type 1: ST7 TIM local
      JU    Ty1R; //Type 1: ST7 TIM remote
      JU    NVal; //Type 2: ST1 Subscriber local (not permissible)
      JU    Ty2R; //Type 2: ST1 Subscriber remote
      JU    NVal; //Type 3: local spare
      JU    NVal; //Type 3: local spare
      JU    Ty4L; //Type 4: ST7cc local
      JU    Ty4R; //Type 4: ST7cc remote
      JU    NVal; //Type 5: local spare
      JU    NVal; //Type 5: local spare
      JU    NVal; //Type 6: local spare
      JU    NVal; //Type 6: local spare
      JU    NVal; //Type 7: local spare
      JU    Ty7R; //Type 7: remote SMS central (short message service)

//send diagnoes message: required connection type not available

NVal: SRW   1; //IF current subscriber type is not valid, send a diagnose message
      T     "BasicData".Info1; //message info 1= connection type
      L     DBW [AR1,P#0.0];
      T     "BasicData".Info2; //message info 1 = subscriber no.
      L     W#16#B110;
      T     "BasicData".EventID;

      UC    "Diagnose";

      L     DW#16#0;
      JU    Tran;
Ty0L: L     DW#16#3002F; //complete version refere manual communication picture 7-7
      JU    Tran; //check index
Ty0R: L     DW#16#3302F; //complete version refere manual communication picture 7-9
      JU    Tran; //check index
Ty1L: L     DW#16#30001; //complete version refere manual communication picture 7-11
      JU    Tran; //check index
Ty1R: L     DW#16#30001; //complete version refere manual communication picture 7-12
      JU    Tran; //check index
Ty2R: L     DW#16#3302F; //same mask as a remote ST7 CPU
      SET   ;
      S     #ST1; //type of subscriber is ST1
      JU    Tran; //check index
Ty4L: NOP   0; //ST7cc local
Ty4R: L     DW#16#2F; //ST7cc remote (sending commands to ST7cc is not permissible)
      JU    Tran; //check index
Ty7R: L     DW#16#0; //SMS central: no index should be send to a SMS central !

//delete all unpermissible bits in local send index 0 and 2

Tran: LAR1  P##SI0DisableTimImageMem; //set pointer to local send index 0
      L     LD [AR1,P#0.0];
      AD    ;
      T     LD [AR1,P#0.0];

      L     #TempBuffer; //list of returns
      JL    NoPo;
      JU    RET0; //return is point no. 0
      JU    Ind0; //return is point no. 1
NoPo: JU    BEND; //not possible


//...............................................end of subroutine CLIN......................................................................

BEND: NOP   0;

END_FUNCTION

//_____________________________________________________________________________________________


//_____________________________________________________________________________________________

FUNCTION_BLOCK "XCom"
TITLE =XCom
//The function block is called by FC "BasicTasks" if X communication is required.
//The function block uses a communication buffer of type "XComData" as instance DB.
//The communication will be done by using the SFC "X_SEND" and SFC "X_RCV".
//After receiving datas will be processed by FC "Distribute".
//
//
//
//Message 	Event 	Info1:		Info2:
//no.		ID
//(17) 	B111 :	RcvRetVal	RequestID		receive datas of unknown communication partner (MPI)
//(18) 	B112 :	ComDB no.	SubscrObjNo		destination subscriber object not found
//(64) 	B140 :	ComDB no.	MessageLength		send message length is < 2 byte
//(65) 	B141 :	ComDB no.	MessageLength		current message length is > receive buffer length
//(66) 	B142 :	ComDB no.	MessageLength		send message length > send buffer length
//(67) 	B143 :	ComDB no.	MessageLength		no. of bytes of send message is odd
//(68) 	B144 :	ComDB no.	SendBlockLength	start address + length of all messages > next free byte address in send buffer
//(80) 	B150 :	ComDB no.	0			connection failure appeared
//(80) 	B050 :	ComDB no.	0			connection failure disappeared
//
//
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : XCom
VERSION : 1.4


VAR
  MPINofPartner : WORD ;
  ConnectionStatus : BOOL ;	//connetion is ok (V)
  ConnectionStatusChange : BOOL ;	//connection status has changed (VA)
  SendStatus : BOOL ;	//send direction is ok (S)
  ReceiveStatus : BOOL ;	//receive direction is ok (R)
  IdleTimeActive : BOOL ;	//idle time is running (T)
  Spare_1_5 : BOOL ;
  Spare_1_6 : BOOL ;
  SystemInitialFlag : BOOL ;	//indicator flag for initialisation
  SpareByte2 : BYTE ;
  StartOrgSendData : WORD ;	//start data of FC Create
  StartReceiveBuffer : WORD ;	//start address of receive buffer
  ReceiveBufferLength : INT  := 76;	//fix value = 76 byte
  CurrentReceivedMessage : INT ;	//start address of current data message
  OffsetCurrentOrgBlockSeg : INT ;	//offset to current org segment in a message with more then one org. index
  ReceivedBlockLength : INT ;	//max. 76 bytes when X communiction
  RCV_DataExist : BOOL ;	//receive data are existing (EV)
  RCV_BufferContentsfail : BOOL ;	//receive buffer contents failure (EF)
  ReceiveRuns : BOOL ;	//receive data procedure is in progress (EA)
  RCV_Nil : BOOL ;	//received data will be rejected (NIL)
  ProcessObjectBlocked : BOOL ;	//process object is blocked (PO)
  SubscriberObjectBlocked : BOOL ;	//supscriber object is blocked (TO)
  Spare_3_6 : BOOL ;
  RcvCopyReq : BOOL ;	//receive copy request for FC TestCopy
  SpareByte4 : BYTE ;
  SpareWord1 : INT ;
  SpareWord2 : INT ;
  StartSendBuffer : WORD ;	//start address of send buffer
  SendBufferLength : WORD ;	//length of the complete send buffer
  NextFreeByteAddress : WORD ;
  SendBlockLength : INT ;	//current send data block length
  SendDataExist : BOOL ;	//send data are existing (SV)
  SendBufferContentsfail : BOOL ;	//send buffer contents failure (SF)
  SendRuns : BOOL ;	//send data procedure is in progress (SA)
  DummyPDU : BOOL ;	//dummy PDU in progress (DP)
  WaitForRepeat : BOOL ;	//wait in case of last send procedure will be repeated
  Spare_5_5 : BOOL ;
  Spare_5_6 : BOOL ;
  SendCopyReq : BOOL ;	//send copy request for FC TestCopy
  SpareByte6 : BYTE ;
  TestCopyDBNo : INT ;
  TestCopyFCNo : INT ;
  PresetIdleTime : INT ;
  RunDownIdleTime : INT ;
  DummyPDUData : WORD  := W#16#FFFF;
  ReservingObject : INT ;
  MaxNofDestSubscr : BYTE ;	//max. number of destination subscribers: max.
  ParamNofDestSubscr : BYTE ;	//no. of valid destination subscribers
  StartIndexInSubscrObject : WORD ;	//start address to index in subscriber object
  NofBytesToTransmit : BYTE ;	//number of bytes to transmit
  ConnectionErrorFlags : BYTE ;
  SendFlags : BYTE ;	//send flags (only bit 0)
  DataLossFlags : BYTE ;	//data loss flags (only bit 0)
  MessageLength : BYTE ;	//no. of bytes of the message
  MessageHeaderFieldF1 : BYTE ;	//F1 field of the message header
  MessageHeaderFieldF2 : BYTE ;	//F2 field of the message header
  MessageHeaderFieldF3 : BYTE ;	//F3 field of the message header
  MessageHeaderFieldF4 : BYTE ;	//F4 field of the message header
  NofDestSubscrInMessage : BYTE ;	//no. of destination subscr. in the message / length of subscr. no. in words
  DestinationSubscrNo : INT ;	//destination subscriber number (= current subscriber object)
  DestinationObjectNo : INT ;	//destination object number =7FFF (or 7FF2 or 7FF3 possible if TIM)
  SourceObjectNo : INT ;	//source object number = 7FFF
  StartIndexNo : INT ;	//(=0, 2 or 8)
  YearMonthDayHour : DWORD ;	//year, month, day, hour
  MinSecMillisecStatus : DWORD ;	//minute, second, milli seconds and status flags of time
  X_RCV_RET_VAL : INT ;
  X_SEND_RET_VAL : INT ;
  ReceiveBuffer : ARRAY  [1 .. 38 ] OF WORD ;	//max 76 byte when X communication
  SendBuffer : ARRAY  [1 .. 38 ] OF WORD ;	//min 76 byte, max 65 382 byte
END_VAR
VAR_TEMP
  AnyPointer1 : ANY ;	//anypointer for X_RCV, X_SEND and BLKMOV
  AnyPointer2 : ANY ;	//anypointer for BLKMOV
  RequestID : DWORD ;	//displays MPI of current communication partner or the own MPI no.
  BufferPointer : DWORD ;	//universal buffer pointer
  FoundAddress : DWORD ;	//used for return value of FC Search
  TempBufferLength : INT ;	//temporary length length buffer
  TempIntegerBuffer : INT ;	//temporary integer buffer
  StartConnList : WORD ;	//address of start of connection list
  JumpBoard : BYTE ;	//used for return of subroutines
  NDA : BOOL ;	//new data arrived
  BSY : BOOL ;	//indicates whether function is busy
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!
RUN:  NOP   0;
NETWORK
TITLE =
//check system start and initialisation
      AN    #SystemInitialFlag;
      JC    Init;

      A     "BasicData".SystemStart; //IF system starts
      JC    Init; //THEN initialice DB XComData
//ELSE
//processing idle timer

      L     #RunDownIdleTime;
      L     "BasicData".LastOB1CycleTime;
      -I    ;
      L     L#0;
      >I    ;
      =     #IdleTimeActive;
      JCN   Zero;
      TAK   ;

Zero: T     #RunDownIdleTime;
      JU    Go01; //go on with cyclic program

//presetings after system start in DB XComData

Init: L     0; //presets with value = 0
      T     #OffsetCurrentOrgBlockSeg;
      T     #ReceivedBlockLength;
      T     #SendBlockLength;
      T     #ReservingObject;
      T     #X_RCV_RET_VAL;
      T     #X_SEND_RET_VAL;
      LAR1  P##ConnectionStatus;
      T     DIB [AR1,P#0.0];
      LAR1  P##RCV_DataExist;
      T     DIB [AR1,P#0.0];
      LAR1  P##SendDataExist;
      T     DIB [AR1,P#0.0];

      L     P##MaxNofDestSubscr; //presets with calculated values
      SRD   3;
      T     #StartOrgSendData; //start address of FC Create data
      L     P##ReceiveBuffer;
      SRD   3;
      T     #StartReceiveBuffer;
      L     P##SendBuffer;
      SRD   3;
      T     #StartSendBuffer;
      L     DILG;
      L     #StartSendBuffer;
      -I    ;
      T     #SendBufferLength;

      L     #StartReceiveBuffer; //presets with other static values
      T     #CurrentReceivedMessage;
      L     #StartSendBuffer;
      T     #NextFreeByteAddress;
      L     #PresetIdleTime;
      T     #RunDownIdleTime;

      SET   ;
      S     #SystemInitialFlag;
//preset anypointer X_RCV

Go01: LAR1  P##AnyPointer1; //set address to any pointer X_RCV
      L     W#16#1004; //code for S7 words
      T     LW [AR1,P#0.0];
      L     #ReceiveBufferLength; //
      SRD   1; //converting bytes to words
      T     LW [AR1,P#2.0];
      L     DINO;
      T     LW [AR1,P#4.0];
      L     #StartReceiveBuffer;
      SLD   3;
      OD    DW#16#84000000; //code for DB;
      T     LD [AR1,P#6.0]; //pointer to receive buffer start in DI

//other presets

      SET   ;
      R     #RCV_Nil; //reset display of receive NIL function

//check status of receive data

      A     #RCV_DataExist; //IF any RCV data are still existing
      JC    P3; //THEN call FC Distribute
      A     "BasicData".XPDU_ReceiveIsActive; //ELSE
      A     #ReceiveRuns; //IF receiving is in progress AND own receive was started
      JC    RCV2; //THEN go on with receiving

      A     "BasicData".XPDU_ReceiveIsActive; //ELSE
      AN    #ReceiveRuns; //IF receiving is in progress AND own receive was not started
      JC    P4; //THEN continue with processing the send direction
//ELSE look for new RCV datas
      CALL "X_RCV" (
           EN_DT                    := FALSE,//Check whether CPU received new datas
           RET_VAL                  := #X_RCV_RET_VAL,
           REQ_ID                   := #RequestID,
           NDA                      := #NDA,
           RD                       := #AnyPointer1);

      LAR1  P##X_RCV_RET_VAL;
      A     DIX [AR1,P#0.7]; //IF receive error occured do not processing receive
      JC    P4; //THEN continue with processing the send direction

      AN    #NDA; //IF no new data arrived
      JC    P4; //THEN continue with processing the send direction
//ELSE continue with processing send data
      L     #RequestID; //IF ID of current communication partner is MPI of connected partner
      L     #MPINofPartner;
      ==I   ;
      JC    OK; //THEN go on
//ELSE check the connection description for any other X-communication
      TAK   ; //whether another partner is available
      OD    DW#16#20000; //code for x communication of not defined connections
      T     #RequestID;
      L     "BasicData".StartConnectionDescrList;
      +     L#2; //offset to connection descr.list: start at byte 2
      T     #StartConnList;
      L     "BasicData".ConnectionDescrLength;
      T     #TempBufferLength;

      CALL "Search" (
           NofObjects               := "BasicData".NofConnectionDescription,
           ObjectLength             := #TempBufferLength,
           StartAddress             := #StartConnList,
           CodeWanted               := #RequestID,
           CodeMask                 := DW#16#FFFFFF,
           RET_VAL                  := #FoundAddress);

      L     #FoundAddress; //IF another connection description was found
      L     0;
      >D    ;
      JC    P4; //THEN continue with processing the send direction

      S     #RCV_Nil;
//reject received data via NIL function

      LAR1  P##AnyPointer1; //set address to any pointer X_RCV
      L     0; //NIL
      T     LB [AR1,P#1.0];
      T     LD [AR1,P#2.0];
      T     LD [AR1,P#6.0];

      CALL "X_RCV" (
           EN_DT                    := TRUE,//Check whether CPU received new datas
           RET_VAL                  := #X_RCV_RET_VAL,
           REQ_ID                   := #RequestID,
           NDA                      := #NDA,
           RD                       := #AnyPointer1);//NIL Pointer

      L     W#16#B111;
      T     "BasicData".EventID; //error 17: unknown partner MPI was received
      L     #RequestID;
      T     "BasicData".Info2;
      L     0;
      T     "BasicData".Info1;

      UC    "Diagnose";

      JU    P4; //continue with processing the send direction

OK:   SET   ;
      S     "BasicData".XPDU_ReceiveIsActive;
      S     #ReceiveRuns;

RCV2: CALL "X_RCV" (
           EN_DT                    := TRUE,//Check whether CPU received new datas
           RET_VAL                  := #X_RCV_RET_VAL,
           REQ_ID                   := #RequestID,
           NDA                      := #NDA,
           RD                       := #AnyPointer1);

//check receive error

      AN    DIX [AR1,P#0.7]; //IF failure occured during receive procedure
      JC    Go02;

      R     "BasicData".XPDU_ReceiveIsActive;
      R     #ReceiveRuns;
      R     #ReceiveStatus;

      JU    P4; //continue with processing the send direction

//set several status flags and preset current receive address and length received data record

Go02: AN    #NDA; //IF no new data arrived
      JC    P4; //THEN continue with processing the send direction

      R     "BasicData".XPDU_ReceiveIsActive; //ELSE reset global flag data received
      R     #ReceiveRuns; //reset receiving data in progress
      S     #ReceiveStatus; //set receive status to ok
      R     #RCV_BufferContentsfail; //reset receive buffer contents failure
      L     #StartReceiveBuffer;
      T     #CurrentReceivedMessage; //preset receive buffer pointer
      L     0;
      T     #OffsetCurrentOrgBlockSeg;
      L     #X_RCV_RET_VAL;
      T     #ReceivedBlockLength;

//check whether dummy PDU was received

      LAR1  P##StartReceiveBuffer; //IF dummy PDU was received
      L     DIW [AR1,P#0.0];
      SLD   3;
      LAR1  ;
      L     DIW [AR1,P#0.0];
      L     W#16#FFFF;
      ==I   ;
      JC    P4; //THEN continue with processing the send direction

//set receive copy request

      S     #RcvCopyReq; //set receive copy request for FC TestCopy

P3:   CALL "Distribute" ;

      LAR2  P##MPINofPartner;

//processing send direction

P4:   AN    #WaitForRepeat; //IF repeat function is not active
      JC    cont; //THEN continue with sending

//ELSE check repeat procedure is running

      A     #IdleTimeActive; //IF idle time is still running
      JC    BEND; //THEN wait

//repeat send procedure again

      R     #WaitForRepeat;

cont: A     #DummyPDU; //IF sending dummy PDU is in progress
      JC    P6; //THEN send next dummy PDU

      A     #SendRuns; //IF sending data is in progress
      JC    P7; //THEN continue with sending

//check error processing directly after a going error

      AN    #ConnectionStatus; //IF connection status is fault but send and receive status are ok
      A     #SendStatus;
      A     #ReceiveStatus;
      JC    P8; //THEN continue with processing the going error

//check error processing directly after a coming error

      A     #ConnectionStatus; //IF connection status is ok, but receive status is not ok
      AN    #ReceiveStatus;
      JC    P9; //THEN continue with processing the coming error

      R     #ConnectionStatusChange; //neither an comming nor an going error was detected

//check whether a dummy PDU has to be send

      AN    #ConnectionStatus; //IF connection status is fault
      JC    Dumy; //THEN check whether the dummy PDU can be send

P12:  L     #NextFreeByteAddress; //IF send buffer is empty
      L     #StartSendBuffer;
      -D    ;
      L     0;
      ==D   ;
      JC    Dumy; //THEN check whether the dummy PDU can be send

//ELSE check contents of send buffer for plausibility

      L     0; //preset length pointer
      T     #TempBufferLength;

      L     #StartSendBuffer; //calculate buffer pointer
      SLD   3;
      T     #BufferPointer;

Chck: L     #TempBufferLength; //calculate total length of all messages in send buffer
      L     DIB [#BufferPointer];
      T     #TempIntegerBuffer; //store current message length
      T     "BasicData".Info2; //previous entry of the hole send block length
      +D    ;
      T     #TempBufferLength; //store current total length

      L     2;
      L     #TempIntegerBuffer; //IF current message length is =< 2 byte
      >=I   ;
      L     W#16#B140;
      JC    SBCF; //THEN send buffer contents fault

      TAK   ;
      L     #ReceiveBufferLength; //IF current message length is > receive buffer length
      >I    ;
      L     W#16#B141;
      JC    SBCF; //THEN send buffer contents fault

//set buffer pointer to next message

      L     #TempIntegerBuffer; //add current message length to current buffer pointer
      SLD   3;
      L     #BufferPointer;
      +D    ;
      T     #BufferPointer;

//check whether total bytes of all messages are > then send buffer length

      L     #TempIntegerBuffer; //IF message length > send buffer length
      L     #SendBufferLength;
      >D    ;
      L     W#16#B142;
      JC    SBCF; //THEN send diagnose message: send buffer contents fault

//check current message length for even no. of bytes

      L     #TempIntegerBuffer; //IF no. of bytes of current message is odd
      SRW   1;
      L     W#16#B143;
      JP    SBCF; //THEN send diagnose message: no. of bytes is odd

//calculate the send block length

      L     #ReceiveBufferLength; //IF total length of all send messages is not
      L     #TempBufferLength; //longer then the receive buffer length
      >=I   ;
      JCN   NoTo;
      T     #SendBlockLength; //THEN make send block length topical

//check whether start of send buffer + all messages <= next free byte in send buffer

NoTo: L     #StartSendBuffer; //IF start address + length of all messages >next free byte address
      L     #TempBufferLength; //THEN send buffer contents fault is detected
      T     "BasicData".Info2; //previous entry of the hole send block length
      +D    ;
      L     #NextFreeByteAddress;
      ==D   ; //IF start address + length of all messages = next free byte address
      JC    Plau; //THEN contents of send buffer is plausible

      >D    ;
      L     W#16#B144;
      JC    SBCF; //THEN send buffer contents fault
      JU    Chck;

SBCF: T     "BasicData".EventID;
      S     #SendBufferContentsfail; //contents of send buffer is not plausible!
      L     DINO; //current communication DB
      T     "BasicData".Info1; //info 2 is set before

      UC    "Diagnose";

Dumy: A     #IdleTimeActive; //IF idle time is running any more
      JC    BEND; //THEN continue with sending the dummy PDU

//preparing to send the dummy PDU

P6:   S     #DummyPDU; //displays sending dummy PDU is in progress
      L     2;
      T     #SendBlockLength; //length of the dummy PDU is 2 byte
      L     P##DummyPDUData;
      AD    DW#16#F4FFFFFF; //convert code from DI to DB
      T     #BufferPointer;
      JU    P71; //continue with preparing any-pointer of send procedure

//preparing to send

Plau: R     #SendBufferContentsfail;
      S     #SendDataExist;
      S     #SendRuns;
P7:   L     #StartSendBuffer;
      SLD   3;
      OD    DW#16#84000000;
      T     #BufferPointer; //pointer to start of send buffer

//preset anypointer X_SEND

P71:  LAR1  P##AnyPointer1; //set address to any pointer X_SEND
      L     W#16#1004; //code for S7 words
      T     LW [AR1,P#0.0];
      L     #SendBlockLength; //no. of bytes to send
      SRD   1; //converting to words to send
      T     LW [AR1,P#2.0];
      L     DINO; //DB no.
      T     LW [AR1,P#4.0];
      L     #BufferPointer; //pointer to start address
      T     LD [AR1,P#6.0]; //pointer to send buffer start in current DI

      L     "BasicData".OwnMpiNo; //preset own subscriber no. for send procedure
      T     #RequestID;

//do send procedure

      CALL "X_SEND" (
           REQ                      := TRUE,
           CONT                     := TRUE,
           DEST_ID                  := #MPINofPartner,
           REQ_ID                   := #RequestID,
           SD                       := #AnyPointer1,
           RET_VAL                  := #X_SEND_RET_VAL,
           BUSY                     := #BSY);

//check connection status and restart idle time

      AN    #IdleTimeActive; //trigger idle time again
      S     #IdleTimeActive;

      L     #PresetIdleTime;
      A     #ConnectionStatus; //IF connection status is ok
      JC    Ok; //THEN start idle time with normal preset

      L     2000; //ELSE start idle time with value 2000 ms
Ok:   T     #RunDownIdleTime;

//check whether send procedure is still busy

      A     #BSY; //IF status of send procedure is still busy
      JC    BEND; //THEN wait and end further send processing

//check overload of partner during send procedure

      L     W#16#80B6; //IF send procedure got the old neg. acknowledge
      L     #X_SEND_RET_VAL; //former acknowledge code (RMOS TIM <2.2)
      ==I   ;
      JC    wait;

      L     W#16#80B5; //IF send procedure got the new neg. acknowledge
      ==I   ; //new acknowledge code (RMOS TIM >=2.2)
      JCN   goon; //THEN go on if not

//ELSE repeat last message after waiting

wait: S     #WaitForRepeat; //set flag "repeat last send procedure"
      S     #IdleTimeActive; //trigger idle time again
      L     1000;
      T     #RunDownIdleTime;

//send warning message "communication overload"

      L     W#16#B153; //enter event ID
      T     "BasicData".EventID;

//search for additional diagnose information: subscriber no. and connection no. for diagnose message

      L     "BasicData".StartConnectionDescrList;
      SLD   3; //them by the diagnose message
      LAR1  ;

//loop over all connection descriptions

      L     1;
Loop: T     #TempIntegerBuffer; //no. of next connection descriptions
      L     "BasicData".NofConnectionDescription;
      >I    ;
      JC    NoF1; //faiure: no valid connection description was found

      L     DBW [AR1,P#0.0]; //compare current ComDB with ComDB
      L     "BasicData".CurrentComDB; //of current connection description
      <>I   ;
      JC    next; //IF not found look at next description

      L     #TempIntegerBuffer; //enter no. of current connection description
      T     "BasicData".Info2;
      L     DBW [AR1,P#6.0]; //enter current local subscriber no.
NoF2: T     "BasicData".Info1;

      UC    "Diagnose"; //send diagnose message

      JU    BEND; //end here

next: L     "BasicData".ConnectionDescrLength; //set addresspointer to next connection description
      SLD   3;
      +AR1  ;
      L     #TempIntegerBuffer; //no. of next connection descriptions
      +     1;
      JU    Loop;

NoF1: L     0; //IF faiure: no valid connection description was found
      JU    NoF2; //THEN give a highlighted signal

goon: LAR1  P##X_SEND_RET_VAL;
      AN    DIX [AR1,P#0.7]; //IF no failure occured during send procedure
      S     #SendStatus; //THEN send status is ok

      A     DIX [AR1,P#0.7]; //IF failure occured during send procedure
      R     #SendStatus; //THEN reset status flags
      R     #ReceiveStatus;
      R     #SendRuns;
      R     #DummyPDU;
      JC    P11; //go to failure processing

//check whether connection was not ok before

      ON    #ConnectionStatus; //IF connection was not ok before
      ON    #ReceiveStatus;
      ON    #SendStatus;
      R     #SendRuns; //THEN reset sending data in progress
      R     #DummyPDU; //reset dummy PDU in progress
      JC    P11; //go to failure processing

//do the rest of send procedure

      AN    #SendRuns; //IF send procedure was not running
      R     #DummyPDU; //THEN reset dummy PDU in progress
      JC    P12; //and go back to continue procedure send buffer

      S     #SendCopyReq; //ELSE set send copy request for FC TestCopy
      L     1;
      T     #JumpBoard;

      JC    TEST; //go to call FC TestCopy

Go03: R     #SendRuns; //reset sending data in progress

//check whether all messages from send buffer were send

      L     #NextFreeByteAddress;
      L     #StartSendBuffer;
      -D    ;
      L     #SendBlockLength;
      -D    ;
      L     L#0; //IF all messages from send buffer were send
      ==D   ;
      JC    Clr; //THEN send buffer is clear

      TAK   ; //rest of remained send data byte
      SRW   1; //no. of remaining send data words
      T     #TempBufferLength;

//compressing contents of remaining data in send buffer

      L     #StartSendBuffer; //calculating start of next data block
      L     #SendBlockLength;
      +D    ;
      SLD   3;
      T     #BufferPointer;

//set source and destination pointer for block move

      LAR1  P##AnyPointer2; //set anypointer to source data
      L     W#16#1004; //code for S7 words
      T     LW [AR1,P#0.0];
      L     #TempBufferLength; //no. of words to copy
      T     LW [AR1,P#2.0];
      L     DINO; //DB no.
      T     LW [AR1,P#4.0];
      L     #BufferPointer; //pointer to start address
      OD    DW#16#84000000; //code for DB
      T     LD [AR1,P#6.0]; //pointer to send buffer start in current DI

      LAR1  P##AnyPointer1; //set any pointer to next send data
      L     W#16#1004; //code for S7 words
      T     LW [AR1,P#0.0];
      L     #TempBufferLength; //no. of words to move on top of send buffer
      T     LW [AR1,P#2.0];
      L     #StartSendBuffer; //pointer to start address
      SLD   3;
      OD    DW#16#84000000; //code for DB
      T     LD [AR1,P#6.0]; //pointer to send buffer start in current DI

//compressing send buffer by using block move

      CALL "BLKMOV" (
           SRCBLK                   := #AnyPointer2,
           RET_VAL                  := #TempIntegerBuffer,
           DSTBLK                   := #AnyPointer1);

//prepare for next send procedure

      L     #NextFreeByteAddress; //set new free byte address
      L     #SendBlockLength;
      -D    ;
      T     #NextFreeByteAddress;
      JU    Go04;

//reset send procedure when send buffer is clear

Clr:  R     #SendDataExist; //no more send data existing
      R     #SendRuns; //send procedure is not any mor in progress
      L     #StartSendBuffer; //send buffer is clear
      T     #NextFreeByteAddress;

Go04: L     0;
      T     #SendBlockLength; //current data block length = 0

      JU    P12; //next send data block will be in progress

//processing comming and going connection errors

//check whether it is an going error

P11:  A     #ReceiveStatus;
      A     #SendStatus;
      AN    #ConnectionStatus;
      JC    P8;

//check whether it is an comming error

      ON    #ReceiveStatus;
      ON    #SendStatus;
      A     #ConnectionStatus;
      JC    P9;

      JU    BEND;

//when connection failure disappears

P8:   S     #ConnectionStatus;
      L     W#16#B050;
      JU    Fine;

//when connection failure appears

P9:   R     #ConnectionStatus; //connection status break down
      R     #IdleTimeActive; //reset running idle time
      L     0;
      T     #RunDownIdleTime;

//check whether send buffer is empty or not

      L     #NextFreeByteAddress;
      L     #StartSendBuffer;
      -D    ;
      T     #SendBlockLength; //current data block length
      L     0;
      ==D   ; //IF no sending data exists
      JC    RST; //THEN reset send buffer

//searching for X-PDUs in send buffer

      L     #StartSendBuffer; //set buffer pointer to start of send buffer
      SLD   3;
NeMe: T     #BufferPointer;
      LAR1  ;
      SRD   3;
      L     #NextFreeByteAddress; //IF next address is equal next free byte address
      >=D   ;
      JC    RDY; //THEN send buffer processing is ready

      A     DIX [AR1,P#2.4]; //IF current message is a X PDU
      JC    XPDU; //THEN eliminate this message

//ELSE calculate next message start address:

      L     DIB [AR1,P#0.0];
      SLD   3;
      L     #BufferPointer; //add block length of the message to current address
      +D    ;
      JU    NeMe; //check next message in send block

//eliminate current message because it is a X-PDU

//check whether the XPDU is of the own PLC

XPDU: L     DIW [AR1,P#10.0]; //IF local source subscr. no. is not own subscr. no.
      L     "BasicData".OwnSubscrNo;
      <>I   ;
      JC    CrlX; //THEN clear this XPDU immediately (no further actions)

//check X-PDU is a data message of an process object

      L     DIW [AR1,P#12.0]; //source object no.
      T     #TempIntegerBuffer;

      AN    DIX [AR1,P#3.7]; //IF XPDU is a organisational message
      JC    ORGM; //THEN process OF flag
//ELSE XPDU is a data object of OS
//setting DF flag in OS object
//set address register 1 to org index 0 in Object DB

      OPN   DB [#TempIntegerBuffer];
      L     DBLG;
      +     -6;
      SLD   3; //pointer to start of org index
      LAR1  ;
      L     DBW [AR1,P#0.0]; //load address of org. index 0
      SLD   3;
      LAR1  ; //set address register to org index 0

      SET   ;
      S     DBX [AR1,P#3.4]; //set DF Flag: data send fault
      JU    CrlX; //clear this XPDU

ORGM: L     W#16#7FFF;
      L     DIW [AR1,P#12.0]; //IF source address is no DB no.
      ==I   ;
      JC    Subs; //THEN set OF flag in subscriber object

//setting OF flag in OS object
//set address register 1 to org index 0 in Object DB

      OPN   DB [#TempIntegerBuffer];
      L     DBLG;
      +     -6;
      SLD   3; //pointer to start of org index
      LAR1  ;
      L     DBW [AR1,P#0.0]; //load address of org. index 0
      SLD   3;
      LAR1  ; //set address register to org index 0

      SET   ;
      S     DBX [AR1,P#3.5]; //set OF Flag: data send fault
      JU    CrlX; //clear this XPDU

//setting OF flag in subscriber object

Subs: L     DIW [AR1,P#6.0]; //remote subscriber no.
      SLD   16;
      T     #RequestID;

      CALL "Search" (//search for local object no.
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #RequestID,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #FoundAddress);

      L     0; //IF found address is not negative
      L     #FoundAddress;
      <D    ;
      JC    Fnd; //THEN address found

      L     W#16#B112; //ELSE send error message 18
      T     "BasicData".EventID;
      L     DINO; //current communication DB
      T     "BasicData".Info1;
      L     #RequestID; //destination subscriber no.
      SRD   16;
      T     "BasicData".Info2;
      UC    "Diagnose";

      JU    BEND;

//calculate and set pointer to org.index of send buffer of subscriber object

Fnd:  L     "BasicData".OffsetSendOrgIndex0; //start of send org. index 0 in subscriber adress
      L     #FoundAddress; //plus start address of subscriber object
      +D    ; //= startaddress of send org.index of subscriber object
      SLD   3;
      LAR1  ;
      S     DBX [AR1,P#11.4]; //set OF bit in subsciber object send index 10

//clearing the X-PDU in the XCom DB send buffer

CrlX: LAR1  #BufferPointer; //pointer to current XPDU
      L     DIB [AR1,P#0.0]; //calculate no. of bytes to compress
      T     #TempIntegerBuffer; //no. of bytes of current message

//calculate no. of words which are to be moved

      L     #NextFreeByteAddress;
      L     #BufferPointer;
      SRD   3;
      -D    ;
      L     #TempIntegerBuffer; //no. of bytes which are to be compressed
      -D    ;
      T     #TempBufferLength; //length of block to move

//calculate new next free byte address

      L     #NextFreeByteAddress;
      L     DIB [AR1,P#0.0];
      -D    ;
      T     #NextFreeByteAddress;

//set source and destination pointer for block move

      LAR1  P##AnyPointer2; //set anypointer to source data
      L     W#16#1004; //code for S7 words
      T     LW [AR1,P#0.0];

      L     #TempBufferLength;
      SRD   1; //no. of words to copy
      T     LW [AR1,P#2.0];

      L     #BufferPointer; //calculate source pointer:
      L     #TempIntegerBuffer; //add no. of bytes to pointer
      SLD   3;
      +D    ;
      OD    DW#16#84000000; //code for DB
      T     LD [AR1,P#6.0]; //pointer to next message in current DI

      LAR1  P##AnyPointer1; //set any pointer to next send data

      L     #TempBufferLength; //no. of bytes to move
      SRD   1; //no. of words
      T     LW [AR1,P#2.0];

      L     DINO;
      T     LW [AR1,P#4.0];
      L     #BufferPointer; //pointer to current message (X-PDU)
      OD    DW#16#84000000; //code for DB
      T     LD [AR1,P#6.0]; //pointer to send buffer start in current DI

//compressing send buffer by using block move

      CALL "BLKMOV" (
           SRCBLK                   := #AnyPointer2,
           RET_VAL                  := #TempIntegerBuffer,
           DSTBLK                   := #AnyPointer1);

      L     #BufferPointer;
      JU    NeMe; //go on with next message

//check whether send buffer is clear

RDY:  L     #NextFreeByteAddress; //IF address of next free byte is > then send buffer start
      L     #StartSendBuffer;
      -D    ;
      L     0;
      >D    ;
      JC    NotC; //THEN send buffer is not clear at all

RST:  R     #SendDataExist; //no more send data existing
      L     #StartSendBuffer; //send buffer is clear
      T     #NextFreeByteAddress;
      L     0;
      T     #SendBlockLength; //current data block length = 0
NotC: L     W#16#B150;

Fine: S     #ConnectionStatusChange;

//prepare diagnose message 80 and 81 (B050/B150)

      T     "BasicData".EventID; //enter diagnose ID for diagnose message

      L     "BasicData".StartConnectionDescrList; //set addresspointer 1 to start of connection description
      SLD   3;
      LAR1  ;

      L     "BasicData".NofConnectionDescription; //look for the local partner no.
Look: T     #TempIntegerBuffer; //loop counter
      L     DINO; //current communication DB no.
      L     DBW [AR1,P#0.0]; //IF current communication DB is equal with the entry
      ==I   ;
      JC    EDI; //THEN propper connection disctription found

      L     "BasicData".ConnectionDescrLength;
      SLD   3;
      +AR1  ; //set address pointer to next connection description

      L     #TempIntegerBuffer;
      LOOP  Look;
      L     0; //no propper connection description found
      JU    Err;

EDI:  L     DBW [AR1,P#6.0]; //enter local partner no. to info 1 of diagnose message
Err:  T     "BasicData".Info1;
      L     0;
      T     "BasicData".Info2;

      UC    "Diagnose";
      JU    End;

BEND: L     0;
      T     #JumpBoard;

//call send and receive copy function

TEST: L     0;
      L     #TestCopyFCNo;
      >=I   ;
      JC    BEnd;

      T     #TempIntegerBuffer;
      UC    FC [#TempIntegerBuffer];

      LAR2  P##MPINofPartner; //restore address pointer 2

BEnd: L     #JumpBoard;
      JL    End;
      JU    End;
      JU    Go03;
End:  NOP   0;

END_FUNCTION_BLOCK

//_____________________________________________________________________________________________

DATA_BLOCK DB 511

  TITLE = Data Block for X Communication

  AUTHOR   : SINAUT_7
  FAMILY   : Basic01
  NAME     : XComData
  VERSION  : 0.01

  STRUCT

  MPINofPartner : WORD ;
  ConnectionStatus : BOOL ;	//connetion is ok (V)
  ConnectionStatusChange : BOOL ;	//connection status has changed (VA)
  SendStatus : BOOL ;	//send direction is ok (S)
  ReceiveStatus : BOOL ;	//receive direction is ok (R)
  IdleTimeActive : BOOL ;	//idle time is running (T)
  Spare_1_5 : BOOL ;
  Spare_1_6 : BOOL ;
  SystemInitialFlag : BOOL ;	//indicator flag for initialisation
  SpareByte2 : BYTE ;
  StartOrgSendData : WORD ;	//start data of FC Create
  StartReceiveBuffer : WORD ;	//start address of receive buffer
  ReceiveBufferLength : INT  := 76;	//fix value = 76 byte
  CurrentReceivedMessage : INT ;	//start address of current data message
  OffsetCurrentOrgBlockSeg : INT ;	//offset to current org segment in a message with more then one org. index
  ReceivedBlockLength : INT ;	//max. 76 bytes when X communiction
  RCV_DataExist : BOOL ;	//receive data are existing (EV)
  RCV_BufferContentsfail : BOOL ;	//receive buffer contents failure (EF)
  ReceiveRuns : BOOL ;	//receive data procedure is in progress (EA)
  RCV_Nil : BOOL ;	//received data will be rejected (NIL)
  ProcessObjectBlocked : BOOL ;	//process object is blocked (PO)
  SubscriberObjectBlocked : BOOL ;	//supscriber object is blocked (TO)
  Spare_3_6 : BOOL ;
  RcvCopyReq : BOOL ;	//receive copy request for FC TestCopy
  SpareByte4 : BYTE ;
  SpareWord1 : INT ;
  SpareWord2 : INT ;
  StartSendBuffer : WORD ;	//start address of send buffer
  SendBufferLength : WORD ;	//length of the complete send buffer
  NextFreeByteAddress : WORD ;
  SendBlockLength : INT ;	//current send data block length
  SendDataExist : BOOL ;	//send data are existing (SV)
  SendBufferContentsfail : BOOL ;	//send buffer contents failure (SF)
  SendRuns : BOOL ;	//send data procedure is in progress (SA)
  DummyPDU : BOOL ;	//dummy PDU in progress (DP)
  WaitForRepeat : BOOL ;	//wait in case of last send procedure will be repeated
  Spare_5_5 : BOOL ;
  Spare_5_6 : BOOL ;
  SendCopyReq : BOOL ;	//send copy request for FC TestCopy
  SpareByte6 : BYTE ;
  TestCopyDBNo : INT ;
  TestCopyFCNo : INT ;
  PresetIdleTime : INT ;
  RunDownIdleTime : INT ;
  DummyPDUData : WORD  := W#16#FFFF;
  ReservingObject : INT ;
  MaxNofDestSubscr : BYTE ;	//max. number of destination subscribers: max.
  ParamNofDestSubscr : BYTE ;	//no. of valid destination subscribers
  StartIndexInSubscrObject : WORD ;	//start address to index in subscriber object
  NofBytesToTransmit : BYTE ;	//number of bytes to transmit
  ConnectionErrorFlags : BYTE ;
  SendFlags : BYTE ;	//send flags (only bit 0)
  DataLossFlags : BYTE ;	//data loss flags (only bit 0)
  MessageLength : BYTE ;	//no. of bytes of the message
  MessageHeaderFieldF1 : BYTE ;	//F1 field of the message header
  MessageHeaderFieldF2 : BYTE ;	//F2 field of the message header
  MessageHeaderFieldF3 : BYTE ;	//F3 field of the message header
  MessageHeaderFieldF4 : BYTE ;	//F4 field of the message header
  NofDestSubscrInMessage : BYTE ;	//no. of destination subscr. in the message / length of subscr. no. in words
  DestinationSubscrNo : INT ;	//destination subscriber number (= current subscriber object)
  DestinationObjectNo : INT ;	//destination object number =7FFF (or 7FF2 or 7FF3 possible if TIM)
  SourceObjectNo : INT ;	//source object number = 7FFF
  StartIndexNo : INT ;	//(=0, 2 or 8)
  YearMonthDayHour : DWORD ;	//year, month, day, hour
  MinSecMillisecStatus : DWORD ;	//minute, second, milli seconds and status flags of time
  X_RCV_RET_VAL : INT ;
  X_SEND_RET_VAL : INT ;
  ReceiveBuffer : ARRAY  [1 .. 38 ] OF WORD ;	//max 76 byte when X communication
  SendBuffer : ARRAY  [ 1 .. 380 ] OF WORD ;	//min 76 byte, max 65 382 byte

  END_STRUCT

  BEGIN
		MPINofPartner := W#16#3;
		PresetIdleTime := 5000;



END_DATA_BLOCK

//_____________________________________________________________________________________________


//_____________________________________________________________________________________________

FUNCTION "PartnerMonitor" : VOID
TITLE = PartnerM
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : PartnerM
VERSION : 1.3


VAR_INPUT
  PartnerNo : INT ;	//parntner no.
  MaxConnectTime : INT ;	//max time a permanent connection is hold on
END_VAR
VAR_OUTPUT
  PartnerStatus : WORD ;	//status of max. 8 partners (corresponding to partner no. of var_input above)
END_VAR
VAR_IN_OUT
  GeneralRequest : BOOL ;	//general request
  PermanentCall_On : BOOL ;	//aktivates a permanent connection or call
  PermanentCall_Off : BOOL ;	//deaktivates a permanent connection or call
//copy of subscriber receive and send
END_VAR
VAR_TEMP
  RI4StatusOfDialUpConn_0 : BOOL ;	//status of dial up connection, bit 0
  RI4StatusOfDialUpConn_1 : BOOL ;	//status of dial up connection, bit 1
  RI4StatusPermConn_0 : BOOL ;	//status of permanent connection, bit 0
  RI4StatusPermConn_1 : BOOL ;	//status of permanent connection, bit 1
  RI4BackBoneDialingActive : BOOL ;	//searching for dialing back bone connection is in progress
  RI4DataTransmInWaitState : BOOL ;	//data transmission in monitoring direction is in wait state
  RI4SpareFlag4_6 : BOOL ;
  RI4SpareFlag4_7 : BOOL ;	//(1)receive index 4 (byte 5) of current subscriber object
  RI4SubscriberOk : BOOL ;	//subscriber is ok
  RI4AllCommPathsOk : BOOL ;	//all communication paths are ok
  RI4CommPathBlocked : BOOL ;	//communication path is blocked
  RI4TIMCurrentDeviceID_0 : BOOL ;	//current device ID of TIM (code flag 0)
  RI4TIMCurrentDeviceID_1 : BOOL ;	//current device ID of TIM (code flag 1)
  RI4PollingModeReleased : BOOL ;	//polling mode is released
  RI4PolledInMainCycle : BOOL ;	//subscriber is polled in main cycle
  RI4ContPollActivated : BOOL ;	//continues polling mode is activated
//(2)receive index 8..12 (byte 9) of current
  RI8SpareFlag11_0 : BOOL ;
  RI8SpareFlag11_1 : BOOL ;
  RI8SpareFlag11_2 : BOOL ;
  RI8ClockOk : BOOL ;	//status of partners clock
  RI8DayLightSavingTime : BOOL ;	//day light saving time
  RI8SpareFlag11_5 : BOOL ;
  RI8SpareFlag11_6 : BOOL ;
  RI8SpareFlag11_7 : BOOL ;	//(3)receive index 8..12 (byte 11) of current subscriber object (CPU)
  RI10FirstSysStart : BOOL ;	//first system start
  RI10DataTransmBlocked : BOOL ;	//data transmission is blocked
  RI10CmdControlBlocked : BOOL ;	//command control is blocked
  RI10RequestError : BOOL ;	//request error occured
  RI10OrgMessageFailure : BOOL ;	//originational message has failed
  RI10SpareFlag11_5 : BOOL ;
  RI10SpareFlag11_6 : BOOL ;
  RI10SpareFlag11_7 : BOOL ;	//(4)send index 0 (byte 1) of current subscriber object
  SI0GeneralRequest : BOOL ;	//general request
  SI0SingleRequest : BOOL ;	//single request
  SI0DisableDataTrans : BOOL ;	//disable process data transmission
  SI0EnableDataTrans : BOOL ;	//enable process data transmission
  SI0SpareFlag1_4 : BOOL ;
  SI0CountValueRestoreCmd : BOOL ;	//counter value restorage comand
  SI0DisableWorking : BOOL ;	//disable working of a typical
  SI0EnableWorking : BOOL ;	//enable working of a typical
//(5)send index 2 (byte 2) of current subscriber obje
  SI2BlockCommPath : BOOL ;	//block the communication path
  SI2UnblockCommPath : BOOL ;	//unblock the communication path
  SI2LockTelephoneNoList : BOOL ;	//lock the telephone number list
  SI2UnlockTelephoneNoList : BOOL ;	//unlock the telephone number list
  SI2ActivatePermConnect : BOOL ;	//aktivate a permanent connection
  SI2DeactivatePermConnect : BOOL ;	//deaktivate a permanent connection
  SI2PollInMainCycle : BOOL ;	//poll subscriber in main cycle
  SI2PollInSubCycle : BOOL ;	//poll subscriber in sub cycle
//(4)send index 4 (byte 4) of current subscriber obj
  SI4CompFlSubscrOk : BOOL ;	//compare flag for Subscriber ok
  SI4TriggerByChange : BOOL ;	//trigger to send when status in subscriber object changed
  SI4TriggerByGeneralReq : BOOL ;	//trigger to send by initialisation of a general request
  SI4TriggerBySingleReq : BOOL ;	//trigger to send by initialisation of a single request
  SI4CompFlDataTransDisabl : BOOL ;	//compare flag for data transmission disabled
  SI4CompFlOrgMessFailed : BOOL ;	//compare flag for organisational message has failed (OF)
  SI4CompFlPermCall_On : BOOL ;	//compare flag for command: permanent call activate
  SI4CompFlPermCall_Off : BOOL ;	//compare flag for command: permanent call deactivate
//(5)send index 4 (byte 5) of
  SI4GeneralRequestActive : BOOL ;	//general request is active
  SI4SingleRequestActive : BOOL ;	//single request is active
  SI4GenReqStartReceived : BOOL ;	//start of general request was received
  SI4GenReqIncomplete : BOOL ;	//general request was incomplete
  SI4Index4and6Expected : BOOL ;	//receiving of index 4 + 6 expected
  SI4Index8_to_12Expected : BOOL ;	//receiving of index 8 .. 12 expected
  SI4SpareFlag5_6 : BOOL ;
  SI4SendGenReqEndMessage : BOOL ;	//send general request end message
//(6)send index 8 .. 12 (byte 11) of current su
  SI10FirstSysStart : BOOL ;	//first system start
  SI10DataTransmBlocked : BOOL ;	//data transmission is blocked
  SI10CmdControlBlocked : BOOL ;	//command control is blocked
  SI10RequestError : BOOL ;	//general request error occured
  SI10OrgMessageFailure : BOOL ;	//originational message has failed
  SI10SpareFlag11_5 : BOOL ;
  SI10SpareFlag11_6 : BOOL ;
  SI10SpareFlag11_7 : BOOL ;	//(7)temp. output status flags of PartnerMonitor high byte
  PermanentCallActive : BOOL ;	//continuous poll is activated
  PartnerResourceMissed : BOOL ;	//partner has no more recources available
  PartnerClockOk : BOOL ;	//partners clock is ok
  StatusSpareFlag3 : BOOL ;
  StatusSpareFlag4 : BOOL ;
  StatusSpareFlag5 : BOOL ;
  StatusSpareFlag6 : BOOL ;
  StatusSpareFlag7 : BOOL ;	//(8)temp. output status flags of PartnerMonitor low byte
  SubscriberOk : BOOL ;	//subscriber is ok
  AllCommPathsOk : BOOL ;	//all communication paths are ok
  GeneralRequestStatus0 : BOOL ;	//status flag 0 of general request
  GeneralRequestStatus1 : BOOL ;	//status flag 1 of general request
  DialConnectionStatus0 : BOOL ;	//status flag 0 of dialed connection
  DialConnectionStatus1 : BOOL ;	//status flag 1 of dialed connection
  DialConnectionStatus2 : BOOL ;	//status flag 2 of dialed connection
  BackBoneDialingActive : BOOL ;	//back bone dialing is activated
//internal flags
  TempAR2Buffer : DWORD ;	//for safe and restore the AR2 buffer
  PointerToCurrRcvOrgInd0 : DWORD ;	//pointer to receive index 0 of current subscriber object
  PointerToCurrSendOrgInd0 : DWORD ;	//pointer to send index 0 of current subscriber object
  TempPartnerNo : DWORD ;
  SubscrAddress : DWORD ;
  NoLimit : BOOL ;	//no time limit for permanent calls
  ShutDown : BOOL ;	//automatic shut down of an permanent call when time is comming
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //IF the keyword = 'ST 7' ?
      ==D   ;
      JC    RUN; //THEN TD7-Software can run

      CALL "STP" ;//ELSE Stop the CPU !!!

RUN:  NOP   0;

NETWORK
TITLE = check partner status

      L     #PartnerNo; //load current parameter x :partner no.
      SLD   16; //no. has to be stored in the high word
      T     #TempPartnerNo; //read current Partner no.

//search for subscriber address

      CALL "Search" (
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #TempPartnerNo,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #SubscrAddress);

//check success of search

      L     "BasicData".StartSubscrObjList;
      L     #SubscrAddress;
      <=D   ;
      JC    ok; //IF founded address is ok THEN continue

      AN    "BasicData".SystemStart; //diagnose message can be send only during system start
      BEC   ; //IF not THEN program aborded

//IF not ok, send error message: required subscriber object not found

      L     W#16#B101; //ID for "unknown partner"
      T     "BasicData".EventID;
      L     0; //info 1: no object DB existing
      T     "BasicData".Info1;
      T     #PartnerStatus; //reset partner status
      L     #TempPartnerNo; //info 2: unknown partner no.
      T     "BasicData".Info2;

      UC    "Diagnose"; //send diagnose message

      BEU   ; //IF partner no. was unknown THEN program aborded

//calculate pointer to current subscriber receive index 0

ok:   L     "BasicData".OffsetRcvOrgIndex0;
      +D    ;
      SLD   3;
      T     #PointerToCurrRcvOrgInd0; //pointer to current subscriber receive index 0
      LAR1  ; //set pointer1 to send index 0 in current subscriber object

//calculate pointer to current subscriber send index 0

      L     #SubscrAddress;
      L     "BasicData".OffsetSendOrgIndex0;
      +D    ;
      SLD   3;
      T     #PointerToCurrSendOrgInd0; //pointer to current subscriber send index 0

//safe AR2 pointer because it´s a special thing

      TAR2  #TempAR2Buffer;

//load current subscriber org. index into local index buffer

      LAR2  P##RI4StatusOfDialUpConn_0; //start of local index array

      LAR1  #PointerToCurrRcvOrgInd0;
      L     DBW [AR1,P#4.0]; //load receive index 4, byte 4 and byte 5
      T     LW [AR2,P#0.0];

      L     DBB [AR1,P#9.0]; //load receive index 8, byte 9
      T     LB [AR2,P#2.0];

      L     DBB [AR1,P#11.0]; //load receive index 8, byte 11
      T     LB [AR2,P#3.0];

      LAR1  #PointerToCurrSendOrgInd0;
      L     DBW [AR1,P#1.0]; //load send index 0, high byte and send index 2 low byte
      T     LW [AR2,P#4.0];

      L     DBW [AR1,P#4.0]; //load send index 4, byte 4 and byte 5
      T     LW [AR2,P#6.0];

      L     DBB [AR1,P#11.0]; //load send index 8, byte 11
      T     LB [AR2,P#8.0];

//processing partner status

      A     #RI4SubscriberOk; //display partner status
      =     #SubscriberOk; //output address 1.0

      A     #RI4AllCommPathsOk; //display communication path status
      =     #AllCommPathsOk; //output address 1.1

//processing general request

      AN    #SI4GeneralRequestActive; //status = 0, general request ready without error
      AN    #SI10RequestError;
      R     #GeneralRequestStatus0; //output address 1.2
      R     #GeneralRequestStatus1; //output address 1.3

      A     #SI4GeneralRequestActive; //status = 1, general request started
      AN    #SI4GenReqStartReceived;
      S     #GeneralRequestStatus0; //output address 1.2
      R     #GeneralRequestStatus1; //output address 1.3

      A     #SI4GeneralRequestActive; //status = 2, general request start received
      A     #SI4GenReqStartReceived;
      R     #GeneralRequestStatus0; //output address 1.2
      S     #GeneralRequestStatus1; //output address 1.3

      AN    #SI4GeneralRequestActive; //status = 3, general request ready with error
      A     #SI10RequestError;
      S     #GeneralRequestStatus0; //output address 1.2
      S     #GeneralRequestStatus1; //output address 1.3

//processing status of connection

      AN    #RI4StatusPermConn_0; //status of permanent connection, bit 0
      AN    #RI4StatusPermConn_1; //status of permanent connection, bit 1
      JCN   ConC; //IF both flags = 0 THEN don´t branch

//status of dial up connection

      R     #DialConnectionStatus2; //output address 1.6 of dialed connection
      A     #RI4StatusOfDialUpConn_0;
      =     #DialConnectionStatus0; //output address 1.4 of dialed connection
      A     #RI4StatusOfDialUpConn_1;
      =     #DialConnectionStatus1; //output address 1.5 of dialed connection

      JU    ConP; //check contionus polling mode

//status of permanent connection

ConC: S     #DialConnectionStatus0; //IF status = 3
      R     #DialConnectionStatus1;
      S     #DialConnectionStatus2; //THEN status of dialed connection = 5, => output address 1.4, 1.5, 1.6

      AN    #RI4StatusPermConn_0; //IF status = 2
      R     #DialConnectionStatus0;
      S     #DialConnectionStatus1; //THEN status of dialed connection = 6, => output address 1.4, 1.5, 1.6

      AN    #RI4StatusPermConn_1; //IF status = 1
      R     #DialConnectionStatus0;
      R     #DialConnectionStatus1; //THEN status of dialed connection = 4, => output address 1.4, 1.5, 1.6

//status dialing back bone connection

ConP: A     #RI4BackBoneDialingActive; //searching for dialing back bone connection is in progress
      =     #BackBoneDialingActive; //output address 1.7

//status of permanent call mode

      A     #RI4ContPollActivated; //permanent polling mode is activated
      =     #PermanentCallActive; //output address 0.0, permanent call is activated

//status of data transmission

      A     #RI4DataTransmInWaitState; //data transmission in monitoring direction is in wait state
      =     #PartnerResourceMissed; //output address 0.1, partner has no more recources available

//status of partners clock

      A     #RI8ClockOk; //status of partners clock
      =     #PartnerClockOk; //output address 0.2, clock of partner is ok

//reset not used status flags

      SET   ;
      R     #StatusSpareFlag3; //output address 0.3
      R     #StatusSpareFlag4; //output address 0.4
      R     #StatusSpareFlag5; //output address 0.5
      R     #StatusSpareFlag6; //output address 0.6
      R     #StatusSpareFlag7; //output address 0.7

//processing command direction (not permissible commands will be checked out from FC BasicTask)

//process general request command

      A     #GeneralRequest; //IF manually general request is required
      A     #RI4SubscriberOk; //AND subscriber is ok
      AN    #SI4GeneralRequestActive; //AND no general request is running jet
      S     #SI0GeneralRequest; //THEN send index 0: general request

      A     #GeneralRequest; //reset manually given general request
      R     #GeneralRequest; //every cycle

//check whether the connection time is limited

      SET   ;
      R     #NoLimit; //previous setting is no time limit
      R     #ShutDown; //AND no automatic shut down

      L     #SubscrAddress; //set addresspointer to start of subscriber data in BasicData
      SLD   3;
      LAR1  ;

      L     #MaxConnectTime;
      L     0; //IF min range <= 0  (0 = no limit)
      <=I   ;
      S     #NoLimit; //THEN connection time is not limited
      JC    NoTr; //go on at no trigger

//check whether the connection time has to be triggered

      AN    #SI4CompFlPermCall_On; //IF no comand permanent connection on
      JC    DecT; //THEN only decrement timer

//check the max range of connection time and trigger the timer

      L     #MaxConnectTime;
      L     480; //IF max range > 8 hours
      >I    ;
      L     28800; //28800 sec = 480 min = 8 hours
      JC    SetT; //THEN set timer

      L     #MaxConnectTime; //ELSE calculate seconds
      L     60;
      *I    ;
SetT: T     DBW [AR1,P#14.0]; //trigger remaining conection time

//check whether the connection should be shut down automaticaly

//decrement remaining connection time

DecT: AN    "BasicData".Pulse_1s; //IF second pulse is false
      JC    NoTr; //THEN no further reaction

      L     1; //ELSE check whether the permanent call has to be shut down
      L     DBW [AR1,P#14.0];
      ==I   ;
      S     #ShutDown;
      L     0; //do not decrement when timer <= 0
      <=I   ;
      JC    NoTr;

      TAK   ; //decrement timer
      +     -1;
      T     DBW [AR1,P#14.0];

NoTr: A     #PermanentCall_On; //aktivate a permanent connection call
      AN    #SI4CompFlPermCall_On; //compare flag for permanent call active
      S     #SI2ActivatePermConnect; //aktivate a permanent connection
      A     #PermanentCall_On;
      =     #SI4CompFlPermCall_On;
      R     #PermanentCall_On; //reset command permanent connection call on

      O     #ShutDown; //automaticaly shut down the connection when connection time = 0 s
      O     #PermanentCall_Off; //deaktivates a permanent connection or call
      AN    #SI4CompFlPermCall_Off; //compare flag for permanent call active
      S     #SI2DeactivatePermConnect; //send index 2: deaktivate a permanent connection
      O     #ShutDown;
      O     #PermanentCall_Off;
      =     #SI4CompFlPermCall_Off;
      R     #PermanentCall_Off; //reset command permanent connection or call

//reset connection timer

      AN    #SI4CompFlPermCall_Off;
      JC    BEND;

      L     0;
      T     DBW [AR1,P#14.0];

//return local data to subscriber object

BEND: LAR2  P##RI4StatusOfDialUpConn_0; //start of local index array

      LAR1  #PointerToCurrSendOrgInd0;
      L     LW [AR2,P#4.0];
      T     DBW [AR1,P#1.0]; //restore send index 0, byte 1 and send index 2 byte 0

      L     LB [AR2,P#6.0];
      T     DBB [AR1,P#4.0]; //restore send index 4, byte 0

//output to status flags

      LAR2  P##PermanentCallActive; //transfer of local data to output
      L     LW [AR2,P#0.0];
      T     #PartnerStatus;

//restore AR2

      LAR2  #TempAR2Buffer;

END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION "Trigger" : VOID
TITLE = Trigger
//set trigger impulse in interval or date and time mode
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : Trigger
VERSION : 1.0


VAR_INPUT
  IntervalMode : BOOL ;	//0 = setpoint of date and time, 1 = interval mode
  Hour_Minute : WORD ;	//hour and minute
  Second_Day : WORD ;	//sencond and day
  Month_Year : WORD ;	//month and year
END_VAR
VAR_OUTPUT
  TriggerOutput : BOOL ;	//output is true 1 cycle per interval or when time arrived
END_VAR
VAR_IN_OUT
  Flag : BOOL ;	//edge flag
END_VAR
VAR_TEMP
  CurrentYear : BYTE ;	//current year (see BasicData)
  CurrentMonth : BYTE ;	//current month (see BasicData)
  CurrentDay : BYTE ;	//current day (see BasicData)
  CurrentHour : BYTE ;	//current hour (see BasicData)
  CurrentMinute : BYTE ;	//current minute (see BasicData)
  CurrentSecond : BYTE ;	//current second (see BasicData)
  Currentmillisecond : BYTE ;	//current millisecond (see BasicData)
  CurrentClockStatus : BOOL ;	//current clock status (see BasicData)
  Hour : BYTE ;	//hour
  Minute : BYTE ;	//minute
  Second : BYTE ;	//second
  Day : BYTE ;	//day
  Month : BYTE ;	//month
  Year : BYTE ;	//year
  TempBuffer : BYTE ;	//temporary buffer for calculated values
  Interval_Hour : BOOL ;	//flag monitors whether interval mode hour is choosed
  Interval_Minute : BOOL ;	//flag monitors whether interval mode minute is choosed
  Interval_Second : BOOL ;	//flag monitors whether interval mode second is choosed
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;

      CALL "STP" ;//Stop CPU !!!
RUN:  NOP   0;

NETWORK
TITLE =
//clear internal used flags
      SET   ; //reset flags every cycle
      R     #TriggerOutput;
      R     #Interval_Hour; //flag monitors whether interval mode hour is choosed
      R     #Interval_Minute; //flag monitors whether interval mode minute is choosed
      R     #Interval_Second; //flag monitors whether interval mode second is choosed
      A     "BasicData".SystemStart; //IF system start
      R     #Flag; //THEN reset output edge flag

//read input parameter

      LAR1  P##Hour;
      L     #Hour_Minute; //store input hour_minute to local buffers
      T     LW [AR1,P#0.0];

      L     #Second_Day; //store input second_day to local buffers
      T     LW [AR1,P#2.0];

      L     #Month_Year; //store input month_year to local buffers
      T     LW [AR1,P#4.0];

//check whether interval mode is hour

      AN    #IntervalMode; //IF no interval mode is required
      JC    Date; //THEN go on with checking date and time mode

//check interval hour

      L     #Hour;
      L     B#16#FF;
      ==I   ; //IF no hour interval is detected
      JC    MinI; //THEN go on wheter interval is minute

//check interval hour, but only when system start is in progress

      S     #Interval_Hour; //1 = interval hour
      AN    "BasicData".SystemStart;
      JC    Clck; //no continous check after system start, check clock status

      L     #Minute; //minute / second
      SLW   8;
      L     #Second;
      OW    ;
      L     W#16#FFFF;
      <>I   ;
      L     2; //error detected at parameter 2
      JC    Diag; //send an error message

      L     2;
      T     "BasicData".Info2; //store checked parameter no. for later error will be detected
      L     #Hour;
      JU    ChIn; //check interval

//check interval minute

MinI: L     #Minute;
      ==I   ; //IF no minute interval is detected
      JC    SecI; //THEN go on wheter interval is second

      S     #Interval_Minute; //1 = interval minute
      AN    "BasicData".SystemStart;
      JC    Clck; //no continous check after system start, check clock status

      L     #Second;
      L     B#16#FF;
      <>I   ; //IF no second is choosed
      L     3; //error detected at parameter 3
      JC    Diag; //THEN send error message

      L     #Minute;
      JU    ChIn; //check interval

SecI: L     B#16#FF; //check of interval second
      L     #Second;
      ==I   ;
      L     1; //IF no interval time is detected THEN parameter interval mode is wrong
      JC    Diag; //send error message

      S     #Interval_Second; // 1 = interval second
      AN    "BasicData".SystemStart;
      JC    Clck; //no continous check after system start, check clock status

      L     10;
      L     #Second;
      >I    ; //IF interval second is less then 10 seconds
      L     3; //error detected at parameter 3
      JC    Diag; //THEN send error message

      TAK   ;

ChIn: L     0; //check interval step
      ==I   ;
      TAK   ;
      L     "BasicData".Info2; //current parameter no.
      JC    Diag; //interval step = 0 not permissible, send diagnose message

      TAK   ; //check current interval step value
      BTI   ;
      T     #TempBuffer;
      L     24;
      A     #Interval_Hour; //IF interval step is hour,
      JC    InLp; //THEN check whether it´s a multiple of 24

      L     60; //ELSE check whether it is a multiple of 60
InLp: L     #TempBuffer; //ok when result = 0
      -I    ;
      JP    InLp; //try again if positiv

      L     "BasicData".Info2; //IF the result is negative, the interval step is not permissible
      JM    Diag; //THEN send diagnose message

      JU    Clck; //check clock status

Date: AN    "BasicData".SystemStart; //no interval => check date and time modus only at system start
      JC    Clck; //check clock status

      L     B#16#FF;
      L     #Hour; //IF no hour required
      ==I   ;
      JC    Dmin; //THEN check minute

      L     B#16#23; //IF value of hour is higher then 23
      >I    ;
      L     2;
      JC    Diag; //THEN send a diagnose message

Dmin: L     B#16#FF;
      L     #Minute; //IF no minute required
      ==I   ;
      JC    Dsec; //THEN check seconds

      L     B#16#59; //IF value of minutes is higher then 59
      >I    ;
      L     2;
      JC    Diag; //THEN send a diagnose message

Dsec: L     B#16#FF;
      L     #Second; //IF no second required
      ==I   ;
      JC    Dday; //THEN check day

      L     B#16#59; //IF value of seconds is higher then 59
      >I    ;
      L     3;
      JC    Diag; //THEN send a diagnose message

Dday: L     B#16#FF;
      L     #Day; //IF no day required
      ==I   ;
      JC    DMon; //THEN check month

      L     0; //IF value of month = 0
      ==I   ;
      L     3;
      JC    Diag; //THEN send a diagnose message

      L     #Day; //IF value of day > 31
      L     B#16#31;
      >I    ;
      L     3;
      JC    Diag; //THEN send a diagnose message

DMon: L     B#16#FF; //IF no month is required
      L     #Month;
      ==I   ;
      JC    Clck; //THEN check clock status
      L     0;
      ==I   ;
      L     4; //IF value of month = 0
      JC    Diag; //THEN send a diagnose message

      L     #Month;
      L     B#16#12; //OR value of month > 12
      <=I   ;
      L     4;
      JC    Clck;

Diag: AN    "BasicData".SystemStart; //error messages only will be generated during system initialition
      BEC   ;

      T     "BasicData".Info2; //no. of identified worse parameter
      L     W#16#B113; //error 19: parameter failure
      T     "BasicData".EventID;
      L     114; //default fc number
      T     "BasicData".Info1;

      UC    "Diagnose";
      BEU   ;

Clck: LAR1  P##CurrentYear; //set addresspointer to begin of local variable current year
      L     "BasicData".CurrentDate; //and read current date and time from BasicData
      T     LD [AR1,P#0.0];
      L     "BasicData".CurrentTime;
      T     LD [AR1,P#4.0];

      AN    #CurrentClockStatus; //IF clock is not valid
      BEC   ; //THEN end task

NETWORK
TITLE = check interval

      AN    #IntervalMode; //IF no interval is required
      JC    Year; //THEN check date and time, begin with checking the year

      AN    #Interval_Hour; //IF no interval hour
      JC    IMin; //THEN check interval mintute

      L     #CurrentMinute; //ELSE check whether interval of hour is reached
      L     0; //when minute = 0
      <>I   ;
      BEC   ;

      L     #CurrentHour; //IF current hour = 0
      ==I   ;
      JC    Tol; //THEN have a look at time tolerance

      L     #Hour;
      BTI   ;
      T     #TempBuffer;
      L     #CurrentHour;
      JU    Comm; //Goto common calculation

IMin: AN    #Interval_Minute; //IF no minute interval
      JC    ISec; //THEN look for second interval

      L     0;
      L     #CurrentMinute; //ELSE check current minute interval
      ==I   ; //IF current minute = 0
      JC    Tol; //THEN have a look at time tolerance

      L     #Minute;
      BTI   ;
      T     #TempBuffer;
      L     #CurrentMinute;
Comm: BTI   ; //common calculation

Decr: L     #TempBuffer; //check whether desired interval is reached
      -I    ;
      JP    Decr;

      JZ    Tol; //IF yes, have a look at time tolerance

      BEU   ;

ISec: L     #Second; //check whether interval is second
      BTI   ;
      T     #Second;
      L     #CurrentSecond;
      BTI   ;

Dec:  T     #TempBuffer;
      L     #Second;
      -I    ;
      JPZ   Dec;

      L     #TempBuffer;
      JU    Seco; //check time tolerance of 5 seconds


Year: L     B#16#FF; //------------------ date and time modus required ---------------------------
      L     #Year; //check year
      ==I   ; //IF not year,
      JC    Mon; //THEN goto check month

      L     #CurrentYear; //compare year
      <>I   ; //IF year is not equal
      JC    No; //THEN no trigger

Mon:  L     B#16#FF; //check month
      L     #Month;
      ==I   ; //IF not month
      JC    Day; //THEN got check day

      L     #CurrentMonth; //compare month
      <>I   ; //IF month is not equal
      JC    No; //THEN no trigger

Day:  L     B#16#FF; //check day
      L     #Day;
      ==I   ; //IF not day
      JC    Hour; //THEN goto check hour

      L     #CurrentDay; //compare day
      <>I   ; //IF day is not equal
      JC    No; //THEN no trigger

Hour: L     B#16#FF; //check hour
      L     #Hour;
      ==I   ; //IF no hour
      JC    min; //THEN goto check minute

      L     #CurrentHour; //compare hour
      <>I   ; //IF hour is not equal
      JC    No; //THEN no trigger

min:  L     B#16#FF; //check minute
      L     #Minute;
      ==I   ; //IF not minute
      JC    sec; //THEN got check second

      L     #CurrentMinute; //compare minute
      <>I   ; //IF minute is not equal
      JC    No; //THEN no Trigger

sec:  L     B#16#FF; //check second
      L     #Second;
      ==I   ; //IF not second
      JC    No; //then no reaction

      BTI   ;
      L     #CurrentSecond; //check second
      BTI   ;
      TAK   ;
      -I    ; //IF date and time has not reached at the moment
      JM    End; //THEN wait

      JU    Seco; //ELSE look at time tolerance

Tol:  L     #CurrentSecond;

Seco: L     5; //the time tolerance is 5 seconds
      >=I   ;
No:   R     #Flag;

      BEC   ; //IF time tolerance is passed THEN end
      AN    #Flag; //ELSE
      S     #Flag; //remember output setting
      S     #TriggerOutput; //and set trigger output
End:  NOP   0;

END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION "PartnerStatus" : VOID
TITLE = PartnerS
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : PartnerS
VERSION : 1.0


VAR_INPUT
  Partner1 : INT ;	//1. parntner no.
  Partner2 : INT ;	//2. parntner no.
  Partner3 : INT ;	//3. parntner no.
  Partner4 : INT ;	//4. parntner no.
  Partner5 : INT ;	//5. parntner no.
  Partner6 : INT ;	//6. parntner no.
  Partner7 : INT ;	//7. parntner no.
  Partner8 : INT ;	//8. parntner no.
END_VAR
VAR_OUTPUT
  PartnerStatus : BYTE ;	//status of max. 8 partners (corresponding to partner no. of var_input above)
END_VAR
VAR_TEMP
  Status : BYTE ;	//return value
  LoopCounter : BYTE ;	//loop counter for the check of 8 partner
  PointerToSubscriberOk : DWORD ;	//pointer to subscriber receive index 4
  TempPartnerNo : DWORD ;
  SubscrAddress : DWORD ;
  Partner : ARRAY  [1 .. 8 ] OF INT ;	//array of partner numbers
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //IF the keyword = 'ST 7' ?
      ==D   ;
      JC    RUN; //THEN TD7-Software can run

      CALL "STP" ;//ELSE Stop the CPU !!!

RUN:  NOP   0;

NETWORK
TITLE = check 8 partner status flags in a loop
//presets
      L     0;
      T     #Status;
      LAR1  P##Status;

//check in the partner no.

      LAR2  P##Partner;
      L     #Partner1;
      T     LW [AR2,P#0.0];
      L     #Partner2;
      T     LW [AR2,P#2.0];
      L     #Partner3;
      T     LW [AR2,P#4.0];
      L     #Partner4;
      T     LW [AR2,P#6.0];
      L     #Partner5;
      T     LW [AR2,P#8.0];
      L     #Partner6;
      T     LW [AR2,P#10.0];
      L     #Partner7;
      T     LW [AR2,P#12.0];
      L     #Partner8;
      T     LW [AR2,P#14.0];

//set loop counter

      L     8;
loop: T     #LoopCounter;
      L     LW [AR2,P#0.0]; //load current parameter x :partner no.
      SLD   16; //no. has to be stored in the high word
      T     #TempPartnerNo; //read current Partner no.
      L     0;
      ==D   ; //IF no partner no. = 0
      JC    next; //THEN check next parameter

//ELSE search for current subscriber address

      CALL "Search" (
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #TempPartnerNo,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #SubscrAddress);

//check success of search

      L     "BasicData".StartSubscrObjList;
      L     #SubscrAddress;
      <=D   ;
      JC    ok; //IF founded address is ok THEN continue

      AN    "BasicData".SystemStart; //only during system start, diagnose message can be send for one time
      JC    next;

//IF not ok, send error message: required subscriber object not found

      L     W#16#B101;
      T     "BasicData".EventID; //error no. 1
      L     0;
      T     "BasicData".Info1;
      L     #TempPartnerNo; //missed partner no.
      SRD   16;
      T     "BasicData".Info2;

      UC    "Diagnose";

      JU    next;

//calculate pointer to current subscriber status

ok:   L     "BasicData".OffsetRcvOrgIndex0;
      +D    ;
      +     5;
      SLD   3;
      T     #PointerToSubscriberOk;

//set current partner status

      A     DBX [#PointerToSubscriberOk];
      =     L [AR1,P#0.0];

//check next parameter

next: +AR1  P#0.1; //forewarding of address pointer1 to next status flag
      +AR2  P#2.0;
      L     #LoopCounter;
      LOOP  loop;

//output to status flags

      L     #Status;
      T     #PartnerStatus;

END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION "ListGenerator300" : VOID
TITLE = ListGenerator300
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : ListGene
VERSION : 1.0


VAR_TEMP
  ReqDB_No : WORD ;	//Input for SFC22, desired DB-No to create
  ListDB_Len : WORD ;	//required length of List-DB
  ListDB_RetVal : INT ;	//Returnvalue of SFC22
  ListDB_No : WORD ;	//Nr. of created DB
  LopCount : WORD ;	//Loop counter
  DiagID : WORD ;
  DiagInfo_1 : WORD ;
  DiagInfo_2 : DWORD ;
  TempInt : INT ;
  TempDBW0 : WORD ;
  MinVal : DWORD ;
  SrcPoint : DWORD ;
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!
RUN:  NOP   0;
NETWORK
TITLE =
//System start ?
      A     "BasicData".SystemStart; //System Start is running ?
      S     "BasicData".ObjRefListGen; //set request for list generation
      BEC   ;
NETWORK
TITLE =
//Initialize 1. step: Calculation of Objects in CPU
      AN    "BasicData".ObjRefListGen; //request for list generation ?
      JC    NXT1;
      R     "BasicData".ObjRefListGen; //reset request for list generation
      R     "BasicData".SortObjRefList1; //reset status flag List 1
      R     "BasicData".SortObjRefList2; //reset status flag List 2
      R     "BasicData".ObjRefList1_Error; //reset status flag List 1
      R     "BasicData".ObjRefList2_Error; //reset status flag List 2
      R     "BasicData".ObjRefList1_Avail; //reset flag "List 1 available"
      R     "BasicData".ObjRefList2_Avail; //reset flag "List 2 available"
      S     "BasicData".ObjRefListGenActive; //set general status flag
      S     "BasicData".ObjRefListLen; //set control flag, step 1: calculate length
      L     0;
      T     "BasicData".NofObjectItems1; //clear no of items 1 in BasicData
      T     "BasicData".NofObjectItems2; //clear no of items 2 in BasicData
      JU    GPER;
NETWORK
TITLE =
//Initialize 2.step: Create List DB
NXT1: AN    "BasicData".ObjRefListLen; //no request for object counting ?
      JC    NXT2;
      R     "BasicData".ObjRefListLen; //reset request for object counting
      R     "BasicData".ObjRefList2_Active; //reset internal flag
      L     "BasicData".NofObjectItems1; //no of items 1 in BasicData
      L     0;
      >I    ;
      S     "BasicData".ObjRefList1_Avail; //set flag "List 1 available"
      L     "BasicData".NofObjectItems2; //no of items 2 in BasicData
      <I    ;
      S     "BasicData".ObjRefList2_Avail; //set flag "no items in List 2"
      JU    CRDB; //create DB Object List
NETWORK
TITLE =
//Initialize 3.step: sort Data
NXT2: AN    "BasicData".ObjRefListEntry; //no request for data entry ?
      JC    NXT3;
      R     "BasicData".ObjRefListEntry; //reset request for data entry
      S     "BasicData".SortObjRefList1; //set request for sorting list 1
      L     0;
      L     "BasicData".DB_ObjectList1; //DB_Object_List_1 in BasicData
      ==I   ;
      JC    ITM2;
      T     #ListDB_No;
      OPN   DB [#ListDB_No]; //open DB_List_x
      L     2; //Init-Value for Listpointer
      T     DBW    0; //preset List_Pointer
ITM2: L     0;
      L     "BasicData".DB_ObjectList2; //DB_Object_List_2 in BasicData
      ==I   ;
      JC    NXT3;
      T     #ListDB_No;
      OPN   DB [#ListDB_No]; //open DB_List_x
      L     2; //Init-Value for Listpointer
      T     DBW    0; //preset List_Pointer
NETWORK
TITLE =
//3.step: sort Data
NXT3: ON    "BasicData".ObjRefListGenActive; //no flag "List creation active" ?
      O(    ;
      AN    "BasicData".SortObjRefList1; //no request for sorting list 1 ?
      AN    "BasicData".SortObjRefList2; //no request for sorting list 2 ?
      )     ;
      JC    GPER;
      AN    "BasicData".ObjRefList1_Avail; //list 1 not available ?
      A     "BasicData".SortObjRefList1; //request for sorting list 1 ?
      R     "BasicData".SortObjRefList1; //reset request for sorting list 1
      S     "BasicData".SortObjRefList2; //set request for sorting list 2
      AN    "BasicData".ObjRefList2_Avail; //list 2 not available ?
      A     "BasicData".SortObjRefList2; //request for sorting list 2 ?
      R     "BasicData".SortObjRefList2; //reset request for sorting list 2
      R     "BasicData".ObjRefListGenActive; //reset general status flag
      JC    GPER; //**** Sorting of List 1 / 2 ****
      L     "BasicData".DB_ObjectList1; //DB-No List_1
      A     "BasicData".SortObjRefList1; //request for sorting list 1 ?
      JC    SORT;
      L     "BasicData".DB_ObjectList2; //DB-No List_2
      AN    "BasicData".SortObjRefList2; //no request for sorting list 2 ?
      JC    GPER;
SORT: T     #ListDB_No;
      L     DW#16#7FFF7FFF;
      T     #MinVal; //set MinVal on max. possible value
      OPN   DB [#ListDB_No]; //open DB_List_x
      L     DBLG; //Length of DB_List_x
      L     DBW    0; //next DBD to check
      >I    ; //end of list not yet reached ?
      JC    NXIT; //process next sort step
      L     2;
      T     DBW    0; //preset start-address in DB_List_x
      A     "BasicData".SortObjRefList1; //request for sorting list 1 ?
      R     "BasicData".SortObjRefList1; //reset request for sorting list 1 ?
      S     "BasicData".SortObjRefList2; //reset request for sorting list 2 ?
      JC    GPER;
      A     "BasicData".SortObjRefList2; //request for sorting list 2 ?
      R     "BasicData".SortObjRefList2; //reset request for sorting list 2
      R     "BasicData".ObjRefListGenActive; //reset general status flag
      JC    GPER;
NXIT: L     DBW    0; //start-address for sorting
      T     #TempDBW0; //store temporarily
      SLD   3; //transform into pointer
      LAR1  ; //preset address-register AR1
      T     #SrcPoint; //preset tempor. Src-Pointer
      L     0;
      L     DBD [AR1,P#0.0]; //load first compare-value
      ==D   ;
      JC    SEEK; //next item
      T     #MinVal; //store as Minimum Value
SEEK: L     #TempDBW0;
      +     6;
      T     #TempDBW0; //store temporarily
      L     DBLG; //Length of DB_List_x
      >=I   ; //end of DB_List_x reached ?
      JC    COPY;
      L     #TempDBW0;
      SLD   3; //transform into pointer
      LAR1  ; //preset address-register AR1
      L     0;
      L     DBD [AR1,P#0.0]; //load compare-value
      ==D   ;
      JC    SEEK;
      L     #MinVal; //actual minimum value
      ==D   ; //stored MinVal = new Value ?
      JC    PAFE; //Error !!!!!!!!
      >D    ;
      JC    SEEK; //new compare value is not minimum
      TAK   ;
      T     #MinVal; //store new Minimum value
      TAR1  #SrcPoint; //store AR1 as source pointer
      JU    SEEK;
PAFE: NOP   0; //**** PAFE-Error-Handling ****
      L     0;
      T     DBD [AR1,P#0.0]; //delete incorrect record
      T     DBW [AR1,P#4.0]; //delete incorrect record
NXT0: L     #TempDBW0;
      +     6;
      T     #TempDBW0; //store temporarily
      L     DBLG; //Length of DB_List_x
      >=I   ; //end of DB_List_x reached ?
      JC    END0;
      L     #TempDBW0;
      SLD   3; //transform into pointer
      LAR1  ; //preset address-register AR1
      L     #MinVal;
      L     DBD [AR1,P#0.0]; //load compare-value
      ==D   ;
      JC    PAFE;
      JU    NXT0; //check next record
END0: LAR1  #SrcPoint; //load pointer on incorrect MinValue
      L     DBW [AR1,P#0.0]; //incorrect record, Word 1
      T     #DiagInfo_1;
      L     DBW [AR1,P#2.0]; //incorrect record, Word 2
      T     #DiagInfo_2;
      L     0;
      T     DBD [AR1,P#0.0]; //delete incorrect record
      T     DBW [AR1,P#4.0]; //delete incorrect record
      A     "BasicData".SortObjRefList1; //request for sorting list 1 ?
      S     "BasicData".ObjRefList1_Error; //set Error List 1 in BasicData?
      A     "BasicData".SortObjRefList2; //request for sorting list 2 ?
      S     "BasicData".ObjRefList2_Error; //set Error List 2 in BasicData?
      L     W#16#B108; //Error-ID: records not plausible
      T     #DiagID;
      JU    DIAG; //*****************************
COPY: L     DBW    0; //start-address of DB_List_x
      SLD   3; //transform into pointer format
      LAR2  ; //preset dest-register for copy
      L     #SrcPoint; //Pointer on Minimum Value
      ==D   ; //Minimum value in first record found ?
      JC    END;
      L     #MinVal;
      L     DW#16#7FFF7FFF;
      ==D   ; //List contains only addr.-Infos = 0 ?
      JC    END;
      LAR1  #SrcPoint; //preset source-register for copy
      L     DBD [AR2,P#0.0]; //<copy destination>
      L     DBD [AR1,P#0.0]; //load source: partner-address-info
      T     DBD [AR2,P#0.0]; //transfer to dest.-record in DB_List
      POP   ;
      T     DBD [AR1,P#0.0];
      L     DBW [AR2,P#4.0]; //<copy destination>
      L     DBW [AR1,P#4.0]; //load source: partner-address-info
      T     DBW [AR2,P#4.0]; //transfer to dest.-record in DB_List
      POP   ;
      T     DBW [AR1,P#4.0];
END:  L     DBW    0;
      +     6;
      T     DBW    0; //Preset next record start address
      L     DBLG;
      <I    ;
      JC    GPER;
      L     2;
      T     DBW    0; //preset start-address in DB_List_x
      A     "BasicData".SortObjRefList1; //request for sorting list 1 ?
      R     "BasicData".SortObjRefList1; //reset request for sorting list 1
      S     "BasicData".SortObjRefList2; //set request for sorting list 2
      JC    GPER;
      A     "BasicData".SortObjRefList2; //request for sorting list 2 ?
      R     "BasicData".SortObjRefList2; //reset request for sorting list 2
      R     "BasicData".ObjRefListGenActive; //reset general status flag
      JU    GPER;
NETWORK
TITLE =
//Prepare parameters for Object-Reference-List-Creation.
CRDB: A     "BasicData".ObjRefList1_Avail; //list 1 available ?
      JC    DBNO; //find DB-No List 1
      L     0;
      T     "BasicData".NofObjectItems1; //clear no of items in list 1
      T     "BasicData".DB_ObjectList1; //set DB_List_1 to 0
LST2: AN    "BasicData".ObjRefList2_Active;
      S     "BasicData".ObjRefList2_Active; //internal flag
      A     "BasicData".ObjRefList2_Avail; //list 2 available ?
      JC    DBNO; //find DB-No List 2
      L     0;
      T     "BasicData".NofObjectItems2; //clear no of items in list 2
      T     "BasicData".DB_ObjectList2; //set DB_List_2 to 0
      AN    "BasicData".ObjRefList1_Avail; //list 1 not available ?
      R     "BasicData".ObjRefListGenActive; //reset general status flag
      JU    GPER;
DBNO: L     DBNO; //DB-No of BasicData
LOWD: +     -1;
      T     #ReqDB_No; //List-DB-No to create
      L     0;
      >I    ; //DB-No is plausible ( >0) ?
      JC    CALC;
      L     DBNO; //DB-No of BasicData
HIGH: +     1;
      T     #ReqDB_No; //List-DB-No to create
CALC: NOP   0; //**** preset parameters for SFC22 ****
      L     "BasicData".NofObjectItems1; //no of items in list
      AN    "BasicData".ObjRefList2_Active; //create List 1 ?
      JC    CLEN;
      L     "BasicData".NofObjectItems2; //no of items in list 2
CLEN: L     6; //length of one record in bytes
      *I    ;
      +     2; //offset
      T     #ListDB_Len; //Length of DB_List to create
      L     "BasicData".DB_ObjectList1; //no of DB_List 1
      AN    "BasicData".ObjRefList2_Active; //create List 1 ?
      JC    CMP;
      L     "BasicData".DB_ObjectList2; //no of DB_List 2
CMP:  T     #ListDB_No;
      L     0;
      ==I   ; //DB-List does not yet exist
      JC    CSFC;
      OPN   DB [#ListDB_No]; //DB_List_1 or _2
      L     DBLG; //Length of existing DB_List
      L     #ListDB_Len; //Length of DB_List to create
      >=I   ;
      JC    CLER; //DB_List existing and long enough
NETWORK
TITLE =
//Create List-DB and preset DB BasicData
CSFC: CALL "CREAT_DB" (
           LOW_LIMIT                := #ReqDB_No,
           UP_LIMIT                 := #ReqDB_No,
           COUNT                    := #ListDB_Len,
           RET_VAL                  := #ListDB_RetVal,
           DB_NUMBER                := #ListDB_No);
      L     0;
      L     #ListDB_RetVal;
      ==I   ; //no Error, DB created successfully
      JC    DBOK;
      L     W#16#80B1;
      ==I   ; //DB-No already exists
      JC    NXDB;
      NOP   0; //******* ERROR Handling *******
      A     "BasicData".ObjRefListGenActive; //DB_List-Creation is active ?
      R     "BasicData".ObjRefListGenActive; //reset general status flag
      AN    "BasicData".ObjRefList2_Active; //List 1 to be created ?
      S     "BasicData".ObjRefList1_Error; //set Error List 1 in BasicData?
      S     "BasicData".ObjRefList2_Error; //set Error List 2 in BasicData?
      R     "BasicData".ObjRefList1_Avail; //reset flag "List 1 available"
      R     "BasicData".ObjRefList2_Avail; //reset flag "List 2 available"
      A     "BasicData".ObjRefList2_Active; //List 2 to be created ?
      S     "BasicData".ObjRefList2_Error; //set Error List 2 in BasicData?
      R     "BasicData".ObjRefList2_Avail; //reset flag "List 2 available"
      L     W#16#B107; //Error-ID: List_DB creation impossible
      T     #DiagID;
      L     #ReqDB_No; //No of DB to create
      T     #DiagInfo_1;
      L     #ListDB_RetVal; //Error-Code from CREAT_DB
      T     #DiagInfo_2;
      JU    DIAG; //**************************************
NXDB: OPN   "BasicData";
      L     DBNO; //No of DB BasicData
      L     #ReqDB_No; //DB-No to create
      >I    ;
      JC    LOWD; //DB-No of List < DB-No of BasicData
      JU    HIGH; //DB-No of List > DB-No of BasicData
DBOK: NOP   0; //**** preset new DB with 0 ****
      OPN   DB [#ListDB_No]; //Open new DB
CLER: LAR1  P#0.0;
      L     DBLG;
LOP1: T     #LopCount;
      L     0;
      T     DBB [AR1,P#0.0];
      +AR1  P#1.0;
      L     #LopCount;
      LOOP  LOP1;
      L     2;
      T     DBW    0; //******************************
      AN    "BasicData".ObjRefListEntry; //****** preset BasicData ******
      S     "BasicData".ObjRefListEntry; //set control flag, step 2: enter data
      A     "BasicData".ObjRefList2_Active; //List 2 has been created ?
      JC    DBL2;
      L     #ListDB_No; //No of created List-DB
      T     "BasicData".DB_ObjectList1; //enter List1-DB-No into BasicData
      JU    LST2;
DBL2: L     #ListDB_No; //No of created List-DB
      T     "BasicData".DB_ObjectList2; //enter List2-DB-No into BasicData
      JU    GPER;
NETWORK
TITLE =
//Enter message into diagnosis-buffer
DIAG: CALL "WR_USMSG" (//enter error message in diagnosis buffer
           SEND                     := TRUE,
           EVENTN                   := #DiagID,
           INFO1                    := #DiagInfo_1,
           INFO2                    := #DiagInfo_2,
           RET_VAL                  := #TempInt);

NETWORK
TITLE =
//Enter global Parameter Error in BasicDate
GPER: O     "BasicData".ObjRefList1_Error; //Error List 1 ?
      O     "BasicData".ObjRefList2_Error; //Error List 2 ?
      S     "BasicData".ParameterError; //set global error flag
      BE    ;
END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION "TimeTask" : VOID
TITLE = TimeTask
//
//
//This function is doing the time management. The call has to be placed after call of BasicTask function. It is necessary to
//synchronize the S7 CPU clock with received time from the ST7 TIM (organizational message 256). It handles the time status
//i.e. the daylight saving time flag.
//
//used diagnose messages:
//
//no.		Diagnose IDs	Info1			Info2		comment
//
//(128)	B180		0			0		daylight saving time error: hour is out of range
//(129)	B181		0			date		date error (SFC 0)
//(130)	B182		0			time		time error (SFC 0)
//
//
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : TimeTask
VERSION : 1.3


VAR_TEMP
  SyncMinute : BYTE ;	//sync. time: minute
  SyncSecond : BYTE ;	//sync. time: second
  Sync_mSec4_11 : BYTE ;	//sync. time: milli seconds bit 4 to 11
  SyncTimeValid : BOOL ;	//sync. time: sync. time is valid
  SyncSavingTime : BOOL ;	//sync. time: daylight saving time
  SyncRequest : BOOL ;	//sync. time: sync. request
  SyncSavingTimeAnnounce : BOOL ;	//sync. time: daylight saving time announcement
  Sync_mSec0 : BOOL ;	//sync. time: milli seconds bit 0
  Sync_mSec1 : BOOL ;	//sync. time: milli seconds bit 1
  Sync_mSec2 : BOOL ;	//sync. time: milli seconds bit 2
  Sync_mSec3 : BOOL ;	//sync. time: milli seconds bit 3
  CurrYearMonth : WORD ;	//current time: year and month
  CurrDayHourMinSec : DWORD ;	//current time: day, hour, minute and seconds
  Curr_mSec4_11 : BYTE ;	//current time: milli seconds bit 4 to 11
  CurrTimeValid : BOOL ;	//current time: time is valid
  CurrSavingTime : BOOL ;	//current time: daylight saving time
  Spare : BOOL ;	//current time: spare flag
  CurrSavingTimeAnnounce : BOOL ;	//current time: daylight saving time announcement
  Curr_mSec0 : BOOL ;	//current time: milli seconds bit 0
  Curr_mSec1 : BOOL ;	//current time: milli seconds bit 1
  Curr_mSec2 : BOOL ;	//current time: milli seconds bit 2
  Curr_mSec3 : BOOL ;	//current time: milli seconds bit 3
  NewDateAndTime : DATE_AND_TIME ;	//data record: year, month, day, hour, minute, second, ms, ms/day of the week
  CorrectedReadedYear : WORD ;	//corrected readed year (because of the change to 2000)
  CorrectedCurrentYear : WORD ;	//corrected current year (because of the change to 2000)
  DiagID : INT ;	//return value of sfc´s
  LoopCounter : INT ;
  AddressPointer : DWORD ;
  TimeCheck : BOOL ;	//accept time only after check
  OldTimeValidStatus : BOOL ;	//flag is used to check whether valid status has changed
  OldSavingTimeStatus : BOOL ;	//flag is used to check whether daylight saving time status has changed
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!
RUN:  NOP   0;
NETWORK
TITLE = SNAUT ST7 time management
//system start ?
      AN    "BasicData".SystemStart;
      JC    Cycl;

      S     "BasicData".TimeProcessingActive; //displays function TimeTask is avaliable
      L     "BasicData".LastSyncTime;
      L     B#16#4;
      OD    ; //set time sync. is requested
      T     "BasicData".LastSyncTime;

Cycl: S     #TimeCheck; //time normally has to be checked before it will be accepted
      LAR2  P##NewDateAndTime; //previous settings
      L     0;
      T     #DiagID;

//load last sync. status and current CPU time to local area

      LAR1  P##SyncMinute; //load last sync time second, mS and status
      L     "BasicData".LastSyncTime;
      T     LD [AR1,P#0.0];

      LAR1  P##CurrYearMonth; //load current date and time of CPU
      L     "BasicData".CurrentDate;
      T     LD [AR1,P#0.0];
      L     "BasicData".CurrentTime;
      T     LD [AR1,P#4.0];

//save last time status before processing new time status

      A     #CurrTimeValid; //status of last "time is valid"
      =     #OldTimeValidStatus; //flag is used to check whether valid status has changed

      A     #CurrSavingTime; //status of last "daylight saving time"
      =     #OldSavingTimeStatus; //flag is used to check whether daylight saving time status has changed

//sync. message received ?

      A     #SyncRequest; //IF no sync. message was received
      JC    Read; //THEN go on with reading CPU clock

      S     #SyncRequest; //ELSE set indicator flag again for detecting the next sync. message

//received time valid ?

      AN    #SyncTimeValid; //IF sync time is not valid
      JC    Read; //THEN go on with reading CPU clock

//sync. time second is 59 ?

      L     #SyncSecond; //IF second = 59
      L     B#16#59;
      ==I   ;
      JC    Read; //THEN no sync possible, go on with reading CPU clock

//check whether the CPU clock ever was set

      AN    #CurrTimeValid; //IF current CPU time is not valid
      JC    Take; //THEN take time to set CPU clock without any check

//ELSE check whether daylight saving based on CPU time was active

      X     #SyncSavingTime; //IF daylight time saveing flags are different
      X     #CurrSavingTime;
      A     "BasicData".DaylightSavingActive; //AND daylight saving based on CPU time was active
      JC    Read; //THEN only read CPU clock

      X     #SyncSavingTime; //IF daylight time saveing flags are different
      X     #CurrSavingTime;
      AN    "BasicData".DaylightSavingActive; //AND daylight saving time based on CPU time was activated
      JCN   Stat;

Take: R     #TimeCheck; //THEN take new sync time and status unconditional
      A     #SyncSavingTime; //without time check
      =     #CurrSavingTime;

Stat: A     #SyncTimeValid; //ELSE take time and only status "valid" and "announcement flag"
      =     #CurrTimeValid;
      A     #SyncSavingTimeAnnounce;
      =     #CurrSavingTimeAnnounce;

      L     #SyncSecond;
      BTI   ;
      +     1;
      ITB   ;
      T     #SyncSecond;

//set CPU clock

      LAR1  P##SyncMinute; //transfere sync time to systemfunction input parameter

      L     "BasicData".LastSyncDate; //transfere sync time to systemfunction input parameter
      T     LD [AR2,P#0.0];
      L     LD [AR1,P#0.0];
      AD    DW#16#FFFFFFF0; //set time status to 0 (day of week = sunday)
      T     LD [AR2,P#4.0];

Set:  CALL "SET_CLK" (
           PDT                      := #NewDateAndTime,
           RET_VAL                  := #DiagID);

      L     #DiagID; //check whether an error occured
      L     0;
      <>I   ;
      JC    Diag;

//check whether CPU clock ever was set

Read: AN    #CurrTimeValid;
      JC    BEND;

//read CPU clock

      CALL "READ_CLK" (
           RET_VAL                  := #DiagID,
           CDT                      := #NewDateAndTime);

//reset daylight time save procedure after passing

      AN    #SyncSavingTimeAnnounce;
      A     "BasicData".DaylightSavingActive;
      R     "BasicData".DaylightSavingActive;

//check whether new date and time has to be checked

      AN    #TimeCheck;
      JC    NoCh;

      ON    #SyncSavingTimeAnnounce; //IF announcement for daylight time saving is already given
      O     "BasicData".DaylightSavingActive;
      JC    Chec; //THEN check readed time before accept

//check whether hour has changed

      L     LB [AR2,P#3.0]; //extract the hour from current readed time
      BTI   ;
      L     "BasicData".CurrentDate; //extract the hour from last current time
      AD    DW#16#FF;
      BTI   ;
      -I    ;
      L     1;
      ==I   ; //IF hour has not changed
      JCN   Chec; //check time before accept

      L     LB [AR2,P#3.0]; //extract the hour from current readed time again
      BTI   ;
      A     #SyncSavingTime; //IF last sync time status was daylight time saved
      JC    Dec; //THEN decrement the current hour (change time to winter)

      +     1; //ELSE increment readed hour
      R     #CurrSavingTime; //reset flag daylight time saved
      JU    Rdy;


Dec:  +     -1;
      S     #CurrSavingTime; //set flag daylight time saved (change to summer)

Rdy:  ITB   ;
      T     LB [AR2,P#3.0];
      S     "BasicData".DaylightSavingActive;
      R     #TimeCheck;

//check whether an error occured

      L     B#16#24;
      >=I   ;
      JC    Diag;

      TAK   ;
      L     B#16#0;
      <I    ;
      JC    Diag;

//set clock to new calculated time

      JU    Set;

//correcting the year before comparing (considering the change to year 2000)
//the range of the years will be 090 up to 189

Chec: L     B#16#90;
      L     LB [AR2,P#0.0]; //correct the readed year
      <=I   ;
      JC    YOk1;

      OW    W#16#100; //to manage the change of year from 1999 to 2000, add 100 if year < 90

YOk1: T     #CorrectedReadedYear;

      L     B#16#90;
      L     #CurrYearMonth; //correcting current year
      SRW   8;
      <=I   ;
      JC    YOk2;

      OW    W#16#100; //correction of years < 90 => add 100 years because to manage the change to 2000

YOk2: T     #CorrectedCurrentYear;

//compare procedure: readed date and time is higher then last current date and time

      L     #CorrectedReadedYear; //compare year
      L     #CorrectedCurrentYear;
      >=I   ;
      JCN   BEND;
      >I    ;
      JC    ChOk;

      L     LB [AR2,P#1.0]; //compare month
      L     #CurrYearMonth;
      AW    W#16#FF;
      >=I   ;
      JCN   BEND;
      >I    ;
      JC    ChOk;

      L     LD [AR2,P#2.0]; //compare day, hour, minute and seconds
      L     #CurrDayHourMinSec;
      >=D   ;
      JCN   BEND;
      >D    ;
      JC    ChOk;

      L     LW [AR2,P#6.0]; //compare milli seconds
      AD    DW#16#FFF0;
      L     "BasicData".CurrentTime;
      AD    DW#16#FFF0;
      >=D   ;
      JCN   BEND;
      >D    ;
      JC    ChOk;

//new readed time is ok, last current time is older

ChOk: A     "BasicData".DaylightSavingActive;
      JC    NoCh;

      A     #SyncSavingTime; //accept daylight saving time status
      =     #CurrSavingTime;

//no further checks of current readed time

NoCh: SET   ; //flag displays all function blocks creating a
      S     "BasicData".CpuClockOk; //message with current time of BasicData is possible now
      LAR1  P##CurrTimeValid; //restore time status of current readed time
      L     LB [AR1,P#0.0];
      AW    W#16#F;
      L     LB [AR2,P#7.0];
      AW    W#16#F0;
      OW    ;
      T     LB [AR2,P#7.0];

      L     LD [AR2,P#0.0]; //output of current readed time to BasicData
      T     "BasicData".CurrentDate;
      L     LD [AR2,P#4.0];
      T     "BasicData".CurrentTime;
      JU    BEND;

Diag: LAR2  P##NewDateAndTime;
      L     0;
      T     "BasicData".Info1;
      L     #DiagID;
      ==I   ;
      JCN   SetF; //set fault error detected (SFC 0)

      L     L#0;
      T     "BasicData".Info2; //daylight saving time error: hour is out of range
      L     W#16#B180; //diagnose ID 128
      JU    DiMe; //send Diagnose message

SetF: L     W#16#8080; //date error (SFC 0)
      ==I   ;
      L     LD [AR2,P#0.0]; //date error (SFC 0)
      SRD   8; //eleminate hour
      T     "BasicData".Info2;
      L     W#16#B181; //diagnose ID 129
      JC    DiMe; //send diagnose message

      L     LD [AR2,P#3.0]; //time error (SFC 0)
      T     "BasicData".Info2;
      L     W#16#B182; //diagnose ID 130

DiMe: T     "BasicData".EventID;

      UC    "Diagnose"; //send diagnose message

BEND: LAR1  P##SyncMinute;
      L     LD [AR1,P#0.0]; //restore sync. request
      T     "BasicData".LastSyncTime;

//check whether time status has changed

      A     #CurrTimeValid; //current status "time is valid"
      AN    #OldTimeValidStatus; //old status "time is valid"
      O     ;
      A     #CurrSavingTime; //current status "daylight saving time"
      AN    #OldSavingTimeStatus; //old status "daylight saving time"
      O     ;
      AN    #CurrSavingTime; //current status "daylight saving time"
      A     #OldSavingTimeStatus; //old status "daylight saving time"

      JCN   End;

//check no. of subscriber objects

      L     "BasicData".NofSubscrObjects; //check no. of subscriber objects
      L     0; //IF no. of subscriber objects = 0
      <=I   ;
      JC    End; //THEN ready

//IF time status has changed THEN all partners (ST7 CPUs and ST7cc) must get the information

      L     "BasicData".StartSubscrObjList; //ELSE prepare addresspointers
      SLD   3;
      LAR1  ; //set addresspointer 1 to first subscriber object
      T     #AddressPointer; //set addresspointerbuffer to first subscriber object


//loop over all subscriber objects => only then org.index 8 message will be triggered

      L     "BasicData".NofSubscrObjects; //prepare loop counter
Loop: T     #LoopCounter;

//check subscriber type

      L     0; //IF subscriber type no. = 0 (ST7 CPU)
      L     DBB [AR1,P#6.0]; //THEN process the subcriber object
      ==I   ;
      JC    ok;

      L     4;
      ==I   ; //OR subscriber type no. = 4 (ST7cc)
      JCN   nok; //ELSE not ok => process the next subscriber object

//store time status to current subscriber object

ok:   L     "BasicData".OffsetSendOrgIndex0;
      SLD   3;
      +AR1  ; //set addresspointer 1 to current send org index 0
      SET   ;
      S     DBX [AR1,P#4.1]; //set start flag to send organisational index 8 message
      A     #CurrTimeValid;
      =     DBX [AR1,P#9.3]; //store flag  "time is valid"
      A     #CurrSavingTime;
      =     DBX [AR1,P#9.4]; //store flag  "daylight saving time"

//calculate address of next subscriber object

nok:  L     #AddressPointer;
      L     "BasicData".SubscrObjectLength;
      SLD   3;
      +D    ;
      LAR1  ;
      T     #AddressPointer; //set addresspointerbuffer to next element

      L     #LoopCounter;
      LOOP  Loop; //decrement loop counter and check remaining subscriber objects

End:  NOP   0;

END_FUNCTION

//_____________________________________________________________________________________________

FUNCTION_BLOCK "MTZ01"
TITLE = MTZ01
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : MTZ01
VERSION : 1.0


VAR_INPUT
  PartnerNo : INT ;	//Subscriber-No. of communication-partner
  ST1_MessageNo : INT ;	//ST1-Message-No:	1...250;
  ST1_ObjectNo : INT ;	//ST1-Object-No:	0 or 1...250;
  ST1_IndexNo : INT ;	//ST1-Index-No:	0...255;
  ST1_PACK_Value : INT ;	//ST1-PACK-Value:	0, 4, 8, 16 or 32;
  Enabled : BOOL  := TRUE;	//Enable Functionblock
  ImageMemory : BOOL  := TRUE;	//image-memory-message
  Conditional : BOOL  := TRUE;	//conditional spontanous transm.
  Unconditional : BOOL ;	//unconditional spontanous transm.
  Permanent : BOOL ;	//permanent transm.
  TimeStamp : BOOL ;	//Message with time-stamp ?
  ReverseDirection : BOOL ;	//reverse transm.-direction for ST1-Messages
  InputByte_1 : BYTE ;	//Binary-Info-Source-Byte 1
  InputByte_2 : BYTE ;	//Binary-Info-Source-Byte 2
  InputByte_3 : BYTE ;	//Binary-Info-Source-Byte 3
  InputByte_4 : BYTE ;	//Binary-Info-Source-Byte 4
  DisableMask : DWORD ;	//Disable-mask
  InversionMask : DWORD ;	//Inversion-mask
END_VAR
VAR
  MessageLen : BYTE ;	//Msg_Header_Byte_1: Msg-Length in Bytes
  F1_Bit_0 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 0 = 0
  F1_AE_1 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 1 = AE (2 exp 0)
  F1_AE_2 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 2 = AE (2 exp 1)
  F1_FA : BOOL  := TRUE;	//Msg_Header_Byte_2: F1: Bit 3 = FA: Function Select (TIM / CPU)
  F1_Bit_4 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 4 = 0
  F1_Bit_5 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 5 = 0
  F1_Bit_6 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 6 = 0
  F1_Bit_7 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 7 = 0
  F2_Bit_0 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 0 = 0
  F2_PACK_1 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 1 = PACK 2exp0
  F2_PACK_2 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 2 = PACK 2exp1
  F2_PACK_3 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 3 = PACK 2exp2
  F2_Bit_4 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 4 = 0
  F2_Bit_5 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 5 = 0
  F2_Bit_6 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 6 = 0
  F2_Bit_7 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 7 = 0
  F3_PR : BOOL ;	//Msg_Header_Byte_4: F3: Bit 0: PR = 0/1 = image-mem / send-buffer
  F3_B : BOOL ;	//Msg_Header_Byte_4: F3: Bit 1: B = 1: conditional transm.
  F3_U : BOOL ;	//Msg_Header_Byte_4: F3: Bit 2: U = 1: unconditional transm.
  F3_P : BOOL ;	//Msg_Header_Byte_4: F3: Bit 3: P = 1: permanent transm.
  F3_Z : BOOL ;	//Msg_Header_Byte_4: F3: Bit 4: Z = 1: with time-stamp
  F3_S : BOOL ;	//Msg_Header_Byte_4: F3: Bit 5: S = 1: Object is disabled
  F3_TA_1 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 6: TA (2 exp 0)
  F3_TA_2 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 7: TA (2 exp 1)
  F4_Bit_0 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 0 = 0
  F4_Bit_1 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 1 = 0
  F4_Bit_2 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 2 = 0
  F4_Bit_3 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 3 = 0
  F4_Bit_4 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 4 = 0
  F4_Bit_5 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 5 = 0
  F4_DS : BOOL ;	//Msg_Header_Byte_5: F4: Bit 6: DS = Data-transm. is disabled (not valid)
  F4_DV : BOOL ;	//Msg_Header_Byte_5: F4: Bit 7: DV = Data lost
  MsgHeaderByte_6 : BYTE  := B#16#2;	//Msg_Header_Byte_6: number. of dest. / Len of Dest-Addr. = 2 Bytes
  DestSubscrNo : INT ;	//Destination-Subscr.-No
  DestObjectNo : INT ;	//Destination-Object-No
  ST1MsgObjNo : INT ;	//ST1-message-no. /message- and object-no.
  StartIndexNo : INT ;	//Start-Index-No
  Time_Stamp_1 : DWORD ;	//Time_Stamp: Year, Month, Day, Hour
  Time_Stamp_2 : DWORD ;	//Time_Stamp: Minute, Second, MSec*10, MSec*1/Status
  BinInfo_1_2 : WORD ;	//DATA_INDEX_0: Binary-Info-Byte 1 and 2
  BinInfo_3_4 : WORD ;	//DATA_INDEX_2: Binary-Info-Byte 3 and 4
  OrgIndex_0_Bit_8 : BOOL ;	//ORG_INDEX_0, Bit 8:
  OrgIndex_0_Bit_9 : BOOL ;	//ORG_INDEX_0, Bit 9:
  OrgIndex_0_Bit_10 : BOOL ;	//ORG_INDEX_0, Bit 10:
  OrgIndex_0_Bit_11 : BOOL ;	//ORG_INDEX_0, Bit 11:
  OrgIndex_0_Bit_12 : BOOL ;	//ORG_INDEX_0, Bit 12:
  OrgIndex_0_Bit_13 : BOOL ;	//ORG_INDEX_0, Bit 13:
  OrgIndex_0_Bit_14 : BOOL ;	//ORG_INDEX_0, Bit 14:
  OrgIndex_0_UEA : BOOL ;	//ORG_INDEX_0, Bit 15: param.-transm. request (not valid)
  OrgIndex_0_GA : BOOL ;	//ORG_INDEX_0, Bit 0: GA = general request
  OrgIndex_0_EA : BOOL ;	//ORG_INDEX_0, Bit 1: EA = single request
  OrgIndex_0_DS : BOOL ;	//ORG_INDEX_0, Bit 2: DS = disable data transmission (not valid)
  OrgIndex_0_DF : BOOL ;	//ORG_INDEX_0, Bit 3: DF = enable data transmission (not valid)
  OrgIndex_0_Bit_4 : BOOL ;	//ORG_INDEX_0, Bit 4:
  OrgIndex_0_Bit_5 : BOOL ;	//ORG_INDEX_0, Bit 5:
  OrgIndex_0_BS : BOOL ;	//ORG_INDEX_0, Bit 6:  BS =disable operation (only if AE = 0)
  OrgIndex_0_BF : BOOL ;	//ORG_INDEX_0, Bit 7:  BF = enable operation (only if AE = 0)
  OrgIndex_2_IN : BOOL ;	//ORG_INDEX_2, Bit 8:  IN = Object-DB is initialized
  OrgIndex_2_FR : BOOL ;	//ORG_INDEX_2, Bit 9:  FR = Object is enabled
  OrgIndex_2_SP : BOOL ;	//ORG_INDEX_2, Bit 10: SP = Object was disabled by ORG_0_command "BS"
  OrgIndex_2_EUE : BOOL ;	//ORG_INDEX_2, Bit 11: EUE= First transm. after start done
  OrgIndex_2_ZB : BOOL ;	//ORG_INDEX_2, Bit 12: ZB = Msg sent after status "Time ok"
  OrgIndex_2_Bit_13 : BOOL ;	//ORG_INDEX_2, Bit 13:
  OrgIndex_2_Bit_14 : BOOL ;	//ORG_INDEX_2, Bit 14:
  OrgIndex_2_PF : BOOL ;	//ORG_INDEX_2, Bit 15: PF = parameter error
  OrgIndex_2_Bit_0 : BOOL ;	//ORG_INDEX_2, Bit 0:
  OrgIndex_2_Bit_1 : BOOL ;	//ORG_INDEX_2, Bit 1:
  OrgIndex_2_Bit_2 : BOOL ;	//ORG_INDEX_2, Bit 2:
  OrgIndex_2_Bit_3 : BOOL ;	//ORG_INDEX_2, Bit 3:
  OrgIndex_2_Bit_4 : BOOL ;	//ORG_INDEX_2, Bit 4:
  OrgIndex_2_Bit_5 : BOOL ;	//ORG_INDEX_2, Bit 5:
  OrgIndex_2_Bit_6 : BOOL ;	//ORG_INDEX_2, Bit 6:
  OrgIndex_2_Bit_7 : BOOL ;	//ORG_INDEX_2, Bit 7:
  OrgIndex_4_PR : BOOL ;	//ORG_INDEX_4, Bit 8: PR = remote Object, transm. principle
  OrgIndex_4_Bit_9 : BOOL ;	//ORG_INDEX_4, Bit 9:
  OrgIndex_4_U : BOOL ;	//ORG_INDEX_4, Bit 10: U = remote Object, unconditional transm.
  OrgIndex_4_Bit_11 : BOOL ;	//ORG_INDEX_4, Bit 11:
  OrgIndex_4_Bit_12 : BOOL ;	//ORG_INDEX_4, Bit 12:
  OrgIndex_4_Bit_13 : BOOL ;	//ORG_INDEX_4, Bit 13:
  OrgIndex_4_TA_1 : BOOL ;	//ORG_INDEX_4, Bit 14: TA (2 exp 0) of last remote Object message
  OrgIndex_4_TA_2 : BOOL ;	//ORG_INDEX_4, Bit 15: TA (2 exp 1) of last remote Object message
  OrgIndex_4_Bit_0 : BOOL ;	//ORG_INDEX_4, Bit 0:
  OrgIndex_4_Bit_1 : BOOL ;	//ORG_INDEX_4, Bit 1:
  OrgIndex_4_Bit_2 : BOOL ;	//ORG_INDEX_4, Bit 2:
  OrgIndex_4_Bit_3 : BOOL ;	//ORG_INDEX_4, Bit 3:
  OrgIndex_4_Bit_4 : BOOL ;	//ORG_INDEX_4, Bit 4:
  OrgIndex_4_Bit_5 : BOOL ;	//ORG_INDEX_4, Bit 5:
  OrgIndex_4_Bit_6 : BOOL ;	//ORG_INDEX_4, Bit 6:
  OrgIndex_4_Bit_7 : BOOL ;	//ORG_INDEX_4, Bit 7:
  IntNewSendReq_Data : BOOL ;	//New Send Request for Process-Data
  IntNewSendReq_Param : BOOL ;	//New Send Request for Parameters (not valid)
  IntNewSendReq_GA : BOOL ;	//New Send Request for General Request (GA)
  IntNewSendReq_EA : BOOL ;	//New Send Request for Single Request (EA)
  IntNewSendReq_spare_1 : BOOL ;	//Spare
  IntNewSendReq_spare_2 : BOOL ;	//Spare
  IntNewSendReq_spare_3 : BOOL ;	//Spare
  IntNewSendReq_spare_4 : BOOL ;	//Spare
  IntOldSendReq_Data : BOOL ;	//Old Send Request for Process-Data
  IntOldSendReq_Param : BOOL ;	//Old Send Request for Parameters (not valid)
  IntOldSendReq_GA : BOOL ;	//Old Send Request for General Request (GA)
  IntOldSendReq_EA : BOOL ;	//Old Send Request for Single Request (EA)
  IntOldSendReq_spare_1 : BOOL ;	//Spare
  IntOldSendReq_spare_2 : BOOL ;	//Spare
  IntOldSendReq_spare_3 : BOOL ;	//Spare
  IntOldSendReq_spare_4 : BOOL ;	//*****************************************************************
  IntSpareByte_1 : BOOL ;	//Spare
  NoOfST1_Objects : BYTE ;	//******** END OF INTERNAL STAT_VARS ********
  SubsRecStartAddr : WORD ;	//Start-address of data-record in subscriber-database
  MaxNumbOfPartners : BYTE  := B#16#1;	//SEND_POINTER: max. number of partners
  ParamNumbOfPartners : BYTE ;	//SEND_POINTER: parametr. number of partners
  SendMsgStartAddr : WORD ;	//SEND_POINTER: Start-address of send-message
  NumbOfBytesToSend : BYTE ;	//SEND_POINTER: number of bytes to send, starting with Start Index No
  LinkErrorFlags : BYTE ;	//SEND_POINTER: Link Error flags to partner 1 (...8)
  SendReqFlags : BYTE ;	//SEND_POINTER: Send-request-flags to Partner 1 (...8)
  DataLostFlags : BYTE ;	//SEND_POINTER: Flags to indicate lost messages to partner 1 (...8)
  AddrDataIndex_0 : WORD ;	//BASE_POINTER: Address of DATA-INDEX-0
  AddrOrgIndex_0 : WORD ;	//BASE_POINTER: Address of ORG-INDEX-0
  NumbOfRecvdBytes : BYTE ;	//BASE_POINTER: number of received Bytes in last recv. message
  MaxRecvDataBytes : BYTE ;	//BASE_POINTER: number of max. possible recv. data-bytes
  ST7_ID : BYTE  := B#16#A5;	//BASE_POINTER: SINAUT ST7 Object-DB-ID = A5
  LastByte_SZ : BOOL  := TRUE;	//BASE_POINTER: Last-Byte: SZ = 1: send-pointers available
  LastByte_EA : BOOL ;	//BASE_POINTER: Last-Byte: EA = 1: space for receive addresses (not valid)
  LastByte_EZ : BOOL ;	//BASE_POINTER: Last-Byte: SZ = 1: space for received time stamp (not valid)
  LastByte_Bit_3 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 3:
  LastByte_Bit_4 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 4:
  LastByte_Bit_5 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 5:
  LastByte_Bit_6 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 6:
  LastByte_Bit_7 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 7:
END_VAR
VAR_TEMP
  SearchPartner : DWORD ;
  SearchRetVal : DWORD ;
  DiagID : WORD ;
  DiagInfo_1 : WORD ;
  DiagInfo_2 : DWORD ;
  DBObjRefList : WORD ;
  ActValue : INT ;
  TempInt : INT ;
  SendReqFlag_0 : BOOL ;
  Save_AR1 : DWORD ;
  Save_AR2 : DWORD ;
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!
RUN:  NOP   0;
NETWORK
TITLE =
//Create Object Reference List 2 ?
      ON    "BasicData".ObjRefListLen; //prepare ref-list-generation
      O     #ReverseDirection; //reverse transmission mode ?
      JC    M000;
      AN    #F1_AE_1; //no AE=1-Telegramme ?
      JC    OBJ1;
      L     0; //default = 1 Object
      L     #ST1_PACK_Value; //Input Parameter
      ==I   ;
      JC    OBJ1;
      L     32; //1 Object = 32 Message-Bits
      ==I   ;
      JC    OBJ1;
      POP   ;
      L     16; //1 Object = 16 Message-Bits
      ==I   ;
      JC    OBJ2;
      POP   ;
      L     8; //1 Object = 8 Message-Bits
      ==I   ;
      JC    OBJ4;
      POP   ;
      L     4; //1 Object = 4 Message-Bits
      <>I   ;
      JC    OBJ1;
      L     8;
      JU    NOOB; //8 Objects in Tgrm
OBJ4: L     4;
      JU    NOOB; //4 Objects in Tgrm
OBJ2: L     2;
      JU    NOOB; //2 Objects in Tgrm
OBJ1: L     1;
NOOB: T     #NoOfST1_Objects; //No of ST1-Obj., depending on Pack
      L     "BasicData".NofObjectItems2; //old number of objects in ref-list
      +I    ;
      T     "BasicData".NofObjectItems2; //new number of objects in ref-list
NETWORK
TITLE =
//Typical-Initialisation and basic settings.
M000: A     #OrgIndex_2_IN; //Object-DB is initialized ?
      JC    STRT;
      S     "BasicData".ObjRefListGen; //request for list generation
      A     #Enabled; //Typical is enabled ?
      S     #OrgIndex_2_FR; //set statusbit "Object is enabled"
      JC    PSET;
      S     #F3_S; //set "Object disabled" in Msg-header
      JU    PSET;
STRT: A     "BasicData".SystemStart; //System-Startup ?
      R     #OrgIndex_2_PF; //reset parameter error
      AN    "BasicData".SystemStart; //no System-Startup ?
      AN    #OrgIndex_2_PF; //no parameter error ?
      JC    M002;
      LAR1  P##OrgIndex_2_IN; //set pointer on INDEX_2 Word
      L     DIW [AR1,P#0.0]; //INDEX_2 in Akku 1
      L     2#1000011100000000; //mask on PF,..., SP, FR, IN
      AW    ;
      T     DIW [AR1,P#0.0]; //store INDEX_2
PSET: A     #TimeStamp; //Input: with Time-stamp ?
      =     #F3_Z; //set "with time-stamp" in Msg-header
      A     #Permanent; //Input: permanent transm. ?
      =     #F3_P; //set "permanent transm." in Msg-header
      L     P##MessageLen; //Pointer on first message byte
      SRW   3; //transform into Integervalue
      T     #SendMsgStartAddr; //preset Object-DB
      L     P##BinInfo_1_2; //Pointer on Data Index 0
      SRW   3; //transform into Integervalue
      T     #AddrDataIndex_0; //preset Object-DB
      L     P##OrgIndex_0_Bit_8; //Pointer on Org Index 0
      SRW   3; //transform into Integervalue
      T     #AddrOrgIndex_0; //preset Object-DB
      AN    #OrgIndex_2_IN;
      S     #OrgIndex_2_IN; //set statusbit "Object is initialized"
      LAR1  P##F4_Bit_0; //set pointer on F4-Array
      L     0;
      T     DIB [AR1,P#0.0]; //preset F4-Array with 0
NETWORK
TITLE =
//Preset Object-DB if system startup.
      L     0;
      L     #PartnerNo; //Destination
      ==I   ;
      JC    NOPA; //no specified communication partner
      SLD   16;
      T     #SearchPartner; //preset data for FC_SEARCH
      TAR1  #Save_AR1; //save AR1
      TAR2  #Save_AR2; //save AR2
      CALL "Search" (
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #SearchPartner,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #SearchRetVal);
      LAR1  #Save_AR1; //restore AR1
      LAR2  #Save_AR2; //restore AR2
      L     0;
      L     #SearchRetVal; //result of "SEARCH"
      <=D   ;
      JC    ADOK; //no error in "SEARCH", address = ok
      L     W#16#B101; //Error-ID: PartnerNo not found in Subscr. List
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //unknown Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ERR1: L     W#16#B100; //Error-ID: PartnerNo not valid
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //incorrect Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ADOK: T     #SubsRecStartAddr; //start-addr. in subscr. database
      R     #OrgIndex_2_PF; //reset parameter error
      L     #PartnerNo; //Input: Destination-partner-no
      T     #DestSubscrNo; //dest.-Partner-No in Msg
      L     1;
      T     #ParamNumbOfPartners; //param.  number of Partners
      JU    OBJT;
NOPA: A     #ReverseDirection; //operation in reverse direction ?
      JC    ERR1; //Error: PartnerNo = 0 and rev. Dir.
      R     #OrgIndex_2_PF; //reset parameter error
      L     0;
      T     #SubsRecStartAddr; //start-addr. in subscr. database
      T     #DestSubscrNo; //dest.-Partner-No in Msg
      T     #DestObjectNo; //dest-Object-No in Msg
      T     #ParamNumbOfPartners; //param.  number of Partners
OBJT: AN    #ReverseDirection; //no operation in reverse direction ?
      S     "BasicData".ObjRefListGen; //request for list generation
      AN    #F3_Z; //no time-stamp in message ?
      JC    NO_T;
      L     0;
      T     #Time_Stamp_1; //delete 1. part of time-stamp
      T     #Time_Stamp_2; //delete 2. part of time-stamp
NO_T: L     0;
      T     #SendReqFlags; //clear send-req-mask
      T     #DataLostFlags; //clear data-lost-mask
      T     #LinkErrorFlags; //clear link-error-mask
      T     #NumbOfRecvdBytes; //delete number of recvd bytes
      LAR1  P##OrgIndex_0_Bit_8; //Pointer on Org-Index 0
      T     DIW [AR1,P#0.0]; //delete ORG_INDEX_0 flags
      LAR1  P##IntNewSendReq_Data; //Pointer on internal Send-flags
      T     DIW [AR1,P#0.0]; //delete internal NEW_ and OLD_SendReq-flags
NETWORK
TITLE =
//Preset ST1-Parameters.
      L     0;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >=I   ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     250; //max. value for ST1_Message_No
      >I    ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      L     0;
      <I    ;
      JC    EROB; //Error in Object No.
      >I    ;
      JC    AE1; //ST1-Message with AE = 1
      L     2;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >I    ; //Message_No < 2 and Obj.-No < 1 ?
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      R     #F1_AE_1; //enter AE_ID = 0 into F1-Field
      R     #F1_AE_2; //    "          "          "
      L     0;
      T     #StartIndexNo; //preset Message
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE0R;
      T     #DestObjectNo; //preset Message
      L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
AE0R: L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #DestObjectNo; //preset Message;
      L     DINO; //local Object-No
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
AE1:  S     #F1_AE_1; //enter AE_ID = 1 into F1-Field
      R     #F1_AE_2; //    "          "          "
      L     255;
      L     #ST1_IndexNo; //read Input-parameter
      <I    ;
      JC    ERIN; //Error : Index_No > 255
      L     0;
      <I    ;
      JC    ERIN; //Error : Index_No < 0
      POP   ;
      SLW   1; //multiply with 2
      T     #StartIndexNo; //enter into Message-area
      L     #AddrDataIndex_0; //Start-Addr. DataIndex-0
      TAK   ;
      -I    ;
      T     #AddrDataIndex_0; //corrected Start-Addr. DataIndex-0
      SET   ; //******** ENTER PACK VALUE ********
      R     #F2_PACK_1; //clear Pack-Bit 1
      R     #F2_PACK_2; //clear Pack-Bit 2
      R     #F2_PACK_3; //clear Pack-Bit 3
      L     0; //Defaultvalue: 1 Obj. = 32Bit
      L     #ST1_PACK_Value; //Input-Parameter
      ==I   ;
      S     #F2_PACK_1; //set Pack-Bit 1
      S     #F2_PACK_2; //set Pack-Bit 2
      S     #F2_PACK_3; //set Pack-Bit 3
      JC    PKOK;
      L     8; //1 Object = 8 Bits
      ==I   ;
      S     #F2_PACK_1; //set Pack-Bit 1
      JC    PKOK;
      POP   ; //ST1_PACK_Value into Akku 1
      L     16; //1 Object = 16 Bits
      ==I   ;
      S     #F2_PACK_2; //set Pack-Bit 2
      JC    PKOK;
      POP   ; //ST1_PACK_Value into Akku 1
      L     32; //1 Object = 32 Bits
      ==I   ;
      S     #F2_PACK_1; //set Pack-Bit 1
      S     #F2_PACK_2; //set Pack-Bit 2
      JC    PKOK;
      POP   ; //ST1_PACK_Value into Akku 1
      L     4; //1 Object = 4 Bits
      <>I   ;
      JC    ER12; //Error 12: Pack-Value not allowed
PKOK: L     255;
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      <I    ;
      JC    EROB; //Error: Object-No > 255
      L     #ST1_MessageNo; //Message_No for ST1-Message
      SLW   8; //Shift Message_No into High_Byte
      OW    ;
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE1R;
      T     #ST1MsgObjNo; //enter into Message-area
      L     0;
      T     #DestObjectNo;
      JU    M002;
AE1R: T     #DestObjectNo; //preset Message
      L     DINO; //local Object-No
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
ER10: L     W#16#B103; //Error-ID: ST1_Message_No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_MessageNo; //incorrect ST1-Message-No
      T     #DiagInfo_2;
      JU    PAFE;
EROB: L     W#16#B104; //Error-ID: Object-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_ObjectNo; //incorrect ST1-Object-No
      T     #DiagInfo_2;
      JU    PAFE;
ERIN: L     W#16#B105; //Error-ID: Index-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_IndexNo; //incorrect ST1-Index-No
      T     #DiagInfo_2;
      JU    PAFE;
ER12: L     W#16#B106; //Error-ID: PACK-Value not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_PACK_Value; //incorrect Pack-Value
      T     #DiagInfo_2;
      JU    PAFE;
NETWORK
TITLE =
//Entry in Object-Reference-List required ?
M002: ON    "BasicData".ObjRefListEntry; //enter item in ref-list ?
      O     #ReverseDirection; //reverse transmission mode ?
      JC    NXNW;
      L     "BasicData".DB_ObjectList2; //DB-No. Subscriber List 2
      T     #DBObjRefList; //store temporarily
      L     0;
      T     #ActValue; //temporary Object-Counter
      L     #NoOfST1_Objects; //1, 2 or 4 Objects in Tgrm
LOPL: T     #TempInt; //temporary loopcounter
      L     "BasicData".OwnSubscrNo; //local subscriber no
      OPN   DB [#DBObjRefList]; //open DB ObjRefList1
      L     DBW    0; //address of next free block
      SLD   3; //convert INT into pointer
      LAR1  ; //preset address-reg. 1
      POP   ; //transfer subscrNo into akku 1
      T     DBW [AR1,P#0.0]; //store in Ref.List
      L     #ST1MsgObjNo; //local input parameter
      L     #ActValue; //temporary Object-counter
      +I    ;
      T     DBW [AR1,P#2.0]; //store in Ref.List
      L     DINO; //local object No
      T     DBW [AR1,P#4.0]; //store in Ref.List
      L     DBW    0; //old address of next free block
      +     6; //add offset on next free block
      T     DBW    0; //new address of next free block
      L     #ActValue; //temporary Object-counter, old
      +     1;
      T     #ActValue; //temporary Object-Counter, new
      L     #TempInt; //temporary loopcounter
      LOOP  LOPL;
NETWORK
TITLE =
//Enable / disable Typical-Operation
NXNW: AN    #Enabled; //Typical is not enabled ?
      JC    DISA;
      O     #OrgIndex_2_FR; //Typical is already enabled ?
      O     #OrgIndex_2_SP; //Typical was disabled by ORG_Command ?
      JC    NXT1;
      S     #OrgIndex_2_FR; //set status "enabled"
      R     #F3_S; //reset Msg-header-info "disabled"
      S     #OrgIndex_0_EA; //set "single request"-command
NXT1: AN    #OrgIndex_0_BS; //no ORG-Command "disable Typical ?"
      JC    NXT2;
      R     #OrgIndex_0_BS; //reset disable-command
      R     #OrgIndex_2_FR; //reset status "enabled"
      S     #OrgIndex_2_SP; //set status "disabled by ORG-Commend"
      S     #F3_S; //set Msg-header-info "disabled"
      S     #OrgIndex_0_EA; //set "single request"-command
      JU    M003;
NXT2: AN    #OrgIndex_0_BF; //no ORG-Command "enable Typical" ?
      JC    M003;
      R     #OrgIndex_0_BF; //reset enable-command
      S     #OrgIndex_2_FR; //set status "enabled"
      R     #OrgIndex_2_SP; //reset status "disabled by ORG-Commend"
      R     #F3_S; //reset Msg-header-info "disabled"
      S     #OrgIndex_0_EA; //set "single request"-command
      JU    M003;
DISA: AN    #OrgIndex_2_FR; //Typical is already disabled ?
      JC    M003;
      R     #OrgIndex_2_FR; //reset status "enabled"
      R     #OrgIndex_2_SP; //reset status "disabled by ORG-Commend"
      S     #F3_S; //set Msg-header-info "disabled"
      S     #OrgIndex_0_EA; //set "single request"-command
      R     #OrgIndex_0_BS; //reset ORG-Command "disable Typical" ?
      R     #OrgIndex_0_BF; //reset ORG-Command "enable Typical" ?
NETWORK
TITLE =
//Process ORG_Command General Request.
M003: AN    "BasicData".GeneralRequest; //no Gen. Request Flag set ?
      JC    M004;
      L     #ParamNumbOfPartners; //No of param. Partners
      L     0;
      ==I   ;
      JC    NXT5;
      L     #SubsRecStartAddr; //Startaddress of Subs. Description
      L     "BasicData".OffsetRcvOrgIndex0;
      +I    ;
      SLD   3; //Pointerformeat
      LAR1  ; //preset Register Ar1
      AN    DBX [AR1,P#1.0]; //received ORG_INDEX_0_GA = 0 ?
      JC    M004;
NXT5: S     #OrgIndex_0_GA; //set General Request Command
NETWORK
TITLE =
//set EA if first Data transmission after "Time o.k.".
M004: L     0;
      T     #NumbOfRecvdBytes; //delete number of received Bytes
      ON    #F3_Z; //no time-stamp in Msg ?
      O(    ;
      AN    "BasicData".CpuClockOk; //Time of CPU-Clock is not yet ok ?
      AN    "BasicData".TimClockOk; //Time of TIM-Clock is not yet ok ?
      )     ;
      O     #OrgIndex_2_ZB; //"Time ok" already processed ?
      JC    PROC;
      S     #OrgIndex_0_EA; //set "single request"-command
      S     #OrgIndex_2_ZB; //set flag "Time ok" already processed
NETWORK
TITLE =
//SEND_REQUEST because of changed Process-Data.
PROC: AN    #OrgIndex_2_FR; //Typical is not enabled ?
      JC    M005;
      LAR1  P##InputByte_1; //Pointer on first Input-Byte
      L     DID [AR1,P#0.0]; //read current 32 Bit Input-data
      L     #InversionMask; //read IN_parameter INVERSION_MASK
      XOD   ; //invert specified Input-Bits
      L     #DisableMask; //read IN-parameter DISABLE_MASK
      INVD  ;
      AD    ;
      LAR1  P##BinInfo_1_2; //Pointer on Data-Index 0
      A     "BasicData".SystemStart; //System-startup ?
      JC    NXT6; //Read Inputparam. and Process-Data
      L     DID [AR1,P#0.0]; //load previous message image
      ==D   ;
      JC    M005; //no diff. between new and old value
      S     #IntNewSendReq_Data; //set INT_NEW_Send_Request_DATA
      POP   ; //transfer <akku2> into <akku1>
NXT6: T     DID [AR1,P#0.0]; //store new message image
NETWORK
TITLE =
//process SEND_REQUEST for other reasons.
M005: AN    #F4_DS; //Data-transm. is not disabled ?
      JC    NXT8;
      R     #IntNewSendReq_Data; //clear new_transm_req for Proc_Data
NXT8: ON    #IntNewSendReq_Data; //no new_transm_req for Proc_Data ?
      O     #OrgIndex_2_EUE; //first transm. already done ?
      JC    M006;
      S     #OrgIndex_0_EA; //set "single request"-command
NETWORK
TITLE =
//Process send_req_flags
M006: L     #SendReqFlags; //transm._req_flags for FC_CREATE
      L     0;
      <>I   ;
      =     #SendReqFlag_0; //temp. flag
      LAR1  P##IntNewSendReq_Data; //Pointer on internal flags
      A     #OrgIndex_0_GA; //General Request command ?
      A     #OrgIndex_0_EA; //Single Request command ?
      R     #OrgIndex_0_EA; //reset Single Request command ?
      A     #OrgIndex_0_GA; //General Request command ?
      R     #OrgIndex_0_GA; //reset General Request command ?
      S     #IntNewSendReq_GA; //set internal NEW_SEND_REQUEST for GenReq
      R     #IntOldSendReq_EA; //reset internal OLD_SEND_REQUEST for SingleReq
      JC    NX10;
      AN    #OrgIndex_0_EA; //no Single Request command ?
      JC    NX11;
      R     #OrgIndex_0_EA; //reset Single Request command ?
      AN    #IntOldSendReq_GA; //no old_GA_req present ?
      S     #IntNewSendReq_EA; //set internal NEW_SEND_REQUEST for SingleReq
NX10: AN    #OrgIndex_2_EUE; //first transm. not yet processed ?
      S     #OrgIndex_2_EUE; //set flag "first transm. processed"
NX11: A     #IntNewSendReq_Data; //new_transm_req for Proc_Data ?
      JC    M007;
      O     #IntNewSendReq_GA; //IntNewSendReq_GA ?
      O     #IntNewSendReq_EA; //IntNewSendReq_EA ?
      JC    NX12;
      AN    #SendReqFlag_0; //no send request present ?
      BEC   ;
      L     DIB [AR1,P#1.0]; //old internal TX-Req
      T     DIB [AR1,P#0.0]; //new internal TX-Req
      JU    M011;
NX12: AN    #SendReqFlag_0; //no send request present ?
      JC    M008;
      L     DIB [AR1,P#1.0]; //old internal TX-Req
      L     DIB [AR1,P#0.0]; //new internal TX-Req
      OW    ;
      T     DIB [AR1,P#0.0]; //new internal TX-Req
      AN    #F3_PR; //last Msg transm. as Image-Memory-Msg ?
      JC    M008;
      L     1;
      T     #SendReqFlags; //Send-Req for FC_CREATE (1 partner)
      S     #F3_TA_1; //Preset TA with 3
      S     #F3_TA_2; //Preset TA with 3
      JU    M011;
M007: AN    #SendReqFlag_0; //no send request present ?
      JC    M008;
      ON    #F3_PR; //last Msg transm. as Image-Memory-Msg ?
      ON    #IntOldSendReq_Data; //old internal SEND_REQUEST for Data ?
      JC    NX13;
      L     #SendReqFlags; //SEND-Req-Flags for FC_CREATE
      L     #DataLostFlags;
      OW    ;
      T     #DataLostFlags;
NX13: L     DIB [AR1,P#1.0]; //old internal TX-Req
      L     DIB [AR1,P#0.0]; //new internal TX-Req
      OW    ;
      T     DIB [AR1,P#0.0]; //new internal TX-Req
NETWORK
TITLE =
//Prepare message for entry into Send-buffer.
M008: AN    #F3_Z; //no time-stamp in message ?
      JC    NX15;
      AN    "BasicData".CpuClockOk; //CPU-Clock not ok ?
      JC    NX16;
      L     DBD    0; //BasicData, current Time, part 1
      T     #Time_Stamp_1; //write into message
      L     DBD    4; ///BasicData, current Time, part 2
      T     #Time_Stamp_2; //write into message
      JU    NX15;
NX16: AN    "BasicData".TimClockOk; //TIM-Clock not ok ?
      R     #OrgIndex_2_ZB; //reset flag Msg sent after "time ok"
      L     0;
      T     #Time_Stamp_1; //delete 1. Part of time-stamp
      T     #Time_Stamp_2; //delete 2. Part of time-stamp
NX15: L     1;
      T     #SendReqFlags; //Send-Req for FC_CREATE (1 partner)
      L     0;
      T     #NumbOfBytesToSend;
      LAR1  P##IntNewSendReq_Data; //pointer on internal NEW_Send_Request-Byte
      L     DIB [AR1,P#0.0]; //internal NEW_Send_Request-Byte
      L     DIB [AR1,P#1.0]; //internal OLD_Send_Request-Byte
      OW    ;
      T     DIB [AR1,P#0.0]; //internal NEW_Send_Request-Byte
      AN    #IntNewSendReq_Data; //new internal Send_Request_DATA ?
      AN    #IntNewSendReq_EA; //new internal Send_Request_EA ?
      R     #F3_U; //reset F3-Message-Header
      R     #F3_B; //reset F3-Message-Header
      JC    NX17;
      A     #Conditional; //Input Parameter
      S     #F3_B; //Preset F3-Message-Header
      A     #Unconditional; //Input Parameter
      S     #F3_U; //Preset F3-Message-Header
NX17: O     #IntNewSendReq_GA; //new internal SEND_REQUEST_GA ?
      O     #IntNewSendReq_EA; //new internal SEND_REQUEST_EA ?
      JC    NX18;
      R     #F3_TA_1; //Preset TA with 2
      S     #F3_TA_2; //Preset TA with 2
      JU    SET;
NX18: S     #F3_TA_1; //Preset TA with 3
      S     #F3_TA_2; //Preset TA with 3
SET:  AN    #ImageMemory; //Input Parameter
      =     #F3_PR; //Preset F3-Message-Header
      L     4;
      T     #NumbOfBytesToSend; //Preset Message
NETWORK
TITLE =
//Call FC_CREATE, to enter message into DB_Com.
M011: TAR2  #Save_AR2; //save AR2
      CALL "Create" (
           SubscriberObject         := FALSE);
      LAR2  #Save_AR2; //restore AR2
NETWORK
TITLE =
//Process internal Send_Request_Flags.
      LAR1  P##IntNewSendReq_Data; //set pointer on internal flags
      L     #SendReqFlags; //Send_Req_Flags for FC_CREATE
      L     0;
      ==I   ;
      JC    TXOK;
      L     #LinkErrorFlags; //Link_Error_Flags from FC _CREATE
      L     #SendReqFlags; //Send_Req_Flags for FC_CREATE
      <>I   ;
      JC    CHK1;
      A     #OrgIndex_0_GA; //command for General Request ?
      R     #OrgIndex_0_GA; //reset command for General Request
      JC    COPY;
      AN    DIX [AR1,P#0.2]; //no INT_NEW_GA -Bit ?
      JC    COPY;
      R     DIX [AR1,P#0.2]; //reset INT_NEW_GA -Bit
      A     DIX [AR1,P#0.0]; //INT_NEW_DATA  -Bit ?
      JC    COPY;
      L     0;
      T     #SendReqFlags; //clear all Send_Req_Flags for FC_CREATE
      JU    M011; //call FC_CREATE
CHK1: O     #OrgIndex_0_GA; //command for General Request ?
      O     #IntNewSendReq_GA; //internal new Send-Req for GenReq ?
      S     "BasicData".DelayGenReqEnd; //global flag to delay GenReqEnd
COPY: L     DIB [AR1,P#0.0]; //INT_NEW_SEND_Flags
      T     DIB [AR1,P#1.0]; //store to INT_OLD_SEND_Flags
      L     0;
      T     DIB [AR1,P#0.0]; //clear all NEW_SEND_Flags
      BEU   ;
TXOK: T     DIW [AR1,P#0.0]; //clear all NEW_ and OLD_SEND_Flags
      BEU   ;
NETWORK
TITLE =
//Enter errormessage in diagnosis-buffer.
PAFE: S     "BasicData".ParameterError; //set global Error flag
      A     #OrgIndex_2_PF; //parameter error is already set
      BEC   ; // ***** END *****
      S     #OrgIndex_2_PF;
      CALL "WR_USMSG" (//enter error message in diagnosis buffer
           SEND                     := TRUE,
           EVENTN                   := #DiagID,
           INFO1                    := #DiagInfo_1,
           INFO2                    := #DiagInfo_2,
           RET_VAL                  := #TempInt);
      BE    ;
END_FUNCTION_BLOCK

//_____________________________________________________________________________________________

FUNCTION_BLOCK "MTZ02"
TITLE = MTZ02
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : MTZ02
VERSION : 1.0


VAR_INPUT
  PartnerNo : INT ;	//Subscriber-No. of communication-partner
  ST1_MessageNo : INT ;	//ST1-Message-No:	1...250;
  ST1_ObjectNo : INT ;	//ST1-Object-No:	0 or 1...250;
  ST1_IndexNo : INT ;	//ST1-Index-No:	0...255;
  ST1_PACK_Value : INT ;	//ST1-PACK-Value:	0, 4, 8 or 16;
  Enabled : BOOL  := TRUE;	//Enable Functionblock
  ImageMemory : BOOL  := TRUE;	//image-memory-message
  Conditional : BOOL  := TRUE;	//conditional spontanous transm.
  Unconditional : BOOL ;	//unconditional spontanous transm.
  Permanent : BOOL ;	//permanent transm.
  TimeStamp : BOOL ;	//Message with time-stamp ?
  ReverseDirection : BOOL ;	//reverse transm.-direction for ST1-Messages
  InputByte_1 : BYTE ;	//Binary-Info-Source-Byte 1
  InputByte_2 : BYTE ;	//Binary-Info-Source-Byte 2
  DisableMask : WORD ;	//Disable-mask
  InversionMask : WORD ;	//Inversion-mask
END_VAR
VAR
  MessageLen : BYTE ;	//Msg_Header_Byte_1: Msg-Length in Bytes
  F1_Bit_0 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 0 = 0
  F1_AE_1 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 1 = AE (2 exp 0)
  F1_AE_2 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 2 = AE (2 exp 1)
  F1_FA : BOOL  := TRUE;	//Msg_Header_Byte_2: F1: Bit 3 = FA: Function Select (TIM / CPU)
  F1_Bit_4 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 4 = 0
  F1_Bit_5 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 5 = 0
  F1_Bit_6 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 6 = 0
  F1_Bit_7 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 7 = 0
  F2_Bit_0 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 0 = 0
  F2_PACK_1 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 1 = PACK 2exp0
  F2_PACK_2 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 2 = PACK 2exp1
  F2_PACK_3 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 3 = PACK 2exp2
  F2_Bit_4 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 4 = 0
  F2_Bit_5 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 5 = 0
  F2_Bit_6 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 6 = 0
  F2_Bit_7 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 7 = 0
  F3_PR : BOOL ;	//Msg_Header_Byte_4: F3: Bit 0: PR = 0/1 = image-mem / send-buffer
  F3_B : BOOL ;	//Msg_Header_Byte_4: F3: Bit 1: B = 1: conditional transm.
  F3_U : BOOL ;	//Msg_Header_Byte_4: F3: Bit 2: U = 1: unconditional transm.
  F3_P : BOOL ;	//Msg_Header_Byte_4: F3: Bit 3: P = 1: permanent transm.
  F3_Z : BOOL ;	//Msg_Header_Byte_4: F3: Bit 4: Z = 1: with time-stamp
  F3_S : BOOL ;	//Msg_Header_Byte_4: F3: Bit 5: S = 1: Object is disabled
  F3_TA_1 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 6: TA (2 exp 0)
  F3_TA_2 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 7: TA (2 exp 1)
  F4_Bit_0 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 0 = 0
  F4_Bit_1 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 1 = 0
  F4_Bit_2 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 2 = 0
  F4_Bit_3 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 3 = 0
  F4_Bit_4 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 4 = 0
  F4_Bit_5 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 5 = 0
  F4_DS : BOOL ;	//Msg_Header_Byte_5: F4: Bit 6: DS = Data-transm. is disabled (not valid)
  F4_DV : BOOL ;	//Msg_Header_Byte_5: F4: Bit 7: DV = Data lost
  MsgHeaderByte_6 : BYTE  := B#16#2;	//Msg_Header_Byte_6: number. of dest. / Len of Dest-Addr. = 2 Bytes
  DestSubscrNo : INT ;	//Destination-Subscr.-No
  DestObjectNo : INT ;	//Destination-Object-No
  ST1MsgObjNo : INT ;	//ST1-message-no. /message- and object-no.
  StartIndexNo : INT ;	//Start-Index-No
  Time_Stamp_1 : DWORD ;	//Time_Stamp: Year, Month, Day, Hour
  Time_Stamp_2 : DWORD ;	//Time_Stamp: Minute, Second, MSec*10, MSec*1/Status
  BinInfo_1_2 : WORD ;	//DATA_INDEX_0: Binary-Info-Byte 1 and 2
  OrgIndex_0_Bit_8 : BOOL ;	//ORG_INDEX_0, Bit 8:
  OrgIndex_0_Bit_9 : BOOL ;	//ORG_INDEX_0, Bit 9:
  OrgIndex_0_Bit_10 : BOOL ;	//ORG_INDEX_0, Bit 10:
  OrgIndex_0_Bit_11 : BOOL ;	//ORG_INDEX_0, Bit 11:
  OrgIndex_0_Bit_12 : BOOL ;	//ORG_INDEX_0, Bit 12:
  OrgIndex_0_Bit_13 : BOOL ;	//ORG_INDEX_0, Bit 13:
  OrgIndex_0_Bit_14 : BOOL ;	//ORG_INDEX_0, Bit 14:
  OrgIndex_0_UEA : BOOL ;	//ORG_INDEX_0, Bit 15: param.-transm. request (not valid)
  OrgIndex_0_GA : BOOL ;	//ORG_INDEX_0, Bit 0: GA = general request
  OrgIndex_0_EA : BOOL ;	//ORG_INDEX_0, Bit 1: EA = single request
  OrgIndex_0_DS : BOOL ;	//ORG_INDEX_0, Bit 2: DS = disable data transmission (not valid)
  OrgIndex_0_DF : BOOL ;	//ORG_INDEX_0, Bit 3: DF = enable data transmission (not valid)
  OrgIndex_0_Bit_4 : BOOL ;	//ORG_INDEX_0, Bit 4:
  OrgIndex_0_Bit_5 : BOOL ;	//ORG_INDEX_0, Bit 5:
  OrgIndex_0_BS : BOOL ;	//ORG_INDEX_0, Bit 6:  BS =disable operation (only if AE = 0)
  OrgIndex_0_BF : BOOL ;	//ORG_INDEX_0, Bit 7:  BF = enable operation (only if AE = 0)
  OrgIndex_2_IN : BOOL ;	//ORG_INDEX_2, Bit 8:  IN = Object-DB is initialized
  OrgIndex_2_FR : BOOL ;	//ORG_INDEX_2, Bit 9:  FR = Object is enabled
  OrgIndex_2_SP : BOOL ;	//ORG_INDEX_2, Bit 10: SP = Object was disabled by ORG_0_command "BS"
  OrgIndex_2_EUE : BOOL ;	//ORG_INDEX_2, Bit 11: EUE= First transm. after start done
  OrgIndex_2_ZB : BOOL ;	//ORG_INDEX_2, Bit 12: ZB = Msg sent after status "Time ok"
  OrgIndex_2_Bit_13 : BOOL ;	//ORG_INDEX_2, Bit 13:
  OrgIndex_2_Bit_14 : BOOL ;	//ORG_INDEX_2, Bit 14:
  OrgIndex_2_PF : BOOL ;	//ORG_INDEX_2, Bit 15: PF = parameter error
  OrgIndex_2_Bit_0 : BOOL ;	//ORG_INDEX_2, Bit 0:
  OrgIndex_2_Bit_1 : BOOL ;	//ORG_INDEX_2, Bit 1:
  OrgIndex_2_Bit_2 : BOOL ;	//ORG_INDEX_2, Bit 2:
  OrgIndex_2_Bit_3 : BOOL ;	//ORG_INDEX_2, Bit 3:
  OrgIndex_2_Bit_4 : BOOL ;	//ORG_INDEX_2, Bit 4:
  OrgIndex_2_Bit_5 : BOOL ;	//ORG_INDEX_2, Bit 5:
  OrgIndex_2_Bit_6 : BOOL ;	//ORG_INDEX_2, Bit 6:
  OrgIndex_2_Bit_7 : BOOL ;	//ORG_INDEX_2, Bit 7:
  OrgIndex_4_PR : BOOL ;	//ORG_INDEX_4, Bit 8: PR = remote Object, transm. principle
  OrgIndex_4_Bit_9 : BOOL ;	//ORG_INDEX_4, Bit 9:
  OrgIndex_4_U : BOOL ;	//ORG_INDEX_4, Bit 10: U = remote Object, unconditional transm.
  OrgIndex_4_Bit_11 : BOOL ;	//ORG_INDEX_4, Bit 11:
  OrgIndex_4_Bit_12 : BOOL ;	//ORG_INDEX_4, Bit 12:
  OrgIndex_4_Bit_13 : BOOL ;	//ORG_INDEX_4, Bit 13:
  OrgIndex_4_TA_1 : BOOL ;	//ORG_INDEX_4, Bit 14: TA (2 exp 0) of last remote Object message
  OrgIndex_4_TA_2 : BOOL ;	//ORG_INDEX_4, Bit 15: TA (2 exp 1) of last remote Object message
  OrgIndex_4_Bit_0 : BOOL ;	//ORG_INDEX_4, Bit 0:
  OrgIndex_4_Bit_1 : BOOL ;	//ORG_INDEX_4, Bit 1:
  OrgIndex_4_Bit_2 : BOOL ;	//ORG_INDEX_4, Bit 2:
  OrgIndex_4_Bit_3 : BOOL ;	//ORG_INDEX_4, Bit 3:
  OrgIndex_4_Bit_4 : BOOL ;	//ORG_INDEX_4, Bit 4:
  OrgIndex_4_Bit_5 : BOOL ;	//ORG_INDEX_4, Bit 5:
  OrgIndex_4_Bit_6 : BOOL ;	//ORG_INDEX_4, Bit 6:
  OrgIndex_4_Bit_7 : BOOL ;	//ORG_INDEX_4, Bit 7:
  IntNewSendReq_Data : BOOL ;	//New Send Request for Process-Data
  IntNewSendReq_Param : BOOL ;	//New Send Request for Parameters (not valid)
  IntNewSendReq_GA : BOOL ;	//New Send Request for General Request (GA)
  IntNewSendReq_EA : BOOL ;	//New Send Request for Single Request (EA)
  IntNewSendReq_spare_1 : BOOL ;	//Spare
  IntNewSendReq_spare_2 : BOOL ;	//Spare
  IntNewSendReq_spare_3 : BOOL ;	//Spare
  IntNewSendReq_spare_4 : BOOL ;	//Spare
  IntOldSendReq_Data : BOOL ;	//Old Send Request for Process-Data
  IntOldSendReq_Param : BOOL ;	//Old Send Request for Parameters (not valid)
  IntOldSendReq_GA : BOOL ;	//Old Send Request for General Request (GA)
  IntOldSendReq_EA : BOOL ;	//Old Send Request for Single Request (EA)
  IntOldSendReq_spare_1 : BOOL ;	//Spare
  IntOldSendReq_spare_2 : BOOL ;	//Spare
  IntOldSendReq_spare_3 : BOOL ;	//Spare
  IntOldSendReq_spare_4 : BOOL ;	//*****************************************************************
  IntSpareByte_1 : BOOL ;	//Spare
  NoOfST1_Objects : BYTE ;	//******** END OF INTERNAL STAT_VARS ********
  SubsRecStartAddr : WORD ;	//Start-address of data-record in subscriber-database
  MaxNumbOfPartners : BYTE  := B#16#1;	//SEND_POINTER: max. number of partners
  ParamNumbOfPartners : BYTE ;	//SEND_POINTER: parametr. number of partners
  SendMsgStartAddr : WORD ;	//SEND_POINTER: Start-address of send-message
  NumbOfBytesToSend : BYTE ;	//SEND_POINTER: number of bytes to send, starting with Start Index No
  LinkErrorFlags : BYTE ;	//SEND_POINTER: Link Error flags to partner 1 (...8)
  SendReqFlags : BYTE ;	//SEND_POINTER: Send-request-flags to Partner 1 (...8)
  DataLostFlags : BYTE ;	//SEND_POINTER: Flags to indicate lost messages to partner 1 (...8)
  AddrDataIndex_0 : WORD ;	//BASE_POINTER: Address of DATA-INDEX-0
  AddrOrgIndex_0 : WORD ;	//BASE_POINTER: Address of ORG-INDEX-0
  NumbOfRecvdBytes : BYTE ;	//BASE_POINTER: number of received Bytes in last recv. message
  MaxRecvDataBytes : BYTE ;	//BASE_POINTER: number of max. possible recv. data-bytes
  ST7_ID : BYTE  := B#16#A5;	//BASE_POINTER: SINAUT ST7 Object-DB-ID = A5
  LastByte_SZ : BOOL  := TRUE;	//BASE_POINTER: Last-Byte: SZ = 1: send-pointers available
  LastByte_EA : BOOL ;	//BASE_POINTER: Last-Byte: EA = 1: space for receive addresses (not valid)
  LastByte_EZ : BOOL ;	//BASE_POINTER: Last-Byte: SZ = 1: space for received time stamp (not valid)
  LastByte_Bit_3 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 3:
  LastByte_Bit_4 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 4:
  LastByte_Bit_5 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 5:
  LastByte_Bit_6 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 6:
  LastByte_Bit_7 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 7:
END_VAR
VAR_TEMP
  SearchPartner : DWORD ;
  SearchRetVal : DWORD ;
  DiagID : WORD ;
  DiagInfo_1 : WORD ;
  DiagInfo_2 : DWORD ;
  DBObjRefList : WORD ;
  ActValue : INT ;
  TempInt : INT ;
  SendReqFlag_0 : BOOL ;
  Save_AR1 : DWORD ;
  Save_AR2 : DWORD ;
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!

RUN:  NOP   0;

NETWORK
TITLE =
//Create Object Reference List 2 ?
      ON    "BasicData".ObjRefListLen; //prepare ref-list-generation
      O     #ReverseDirection; //reverse transmission mode ?
      JC    M000;
      AN    #F1_AE_1; //no AE=1-Telegramme ?
      JC    OBJ1;
      L     0; //default = 1 Object
      L     #ST1_PACK_Value; //Input Parameter
      ==I   ;
      JC    OBJ1;
      L     16; //1 Object = 16 Message-Bits
      ==I   ;
      JC    OBJ1;
      POP   ;
      L     8; //1 Object = 8 Message-Bits
      ==I   ;
      JC    OBJ2;
      POP   ;
      L     4; //1 Object = 4 Message-Bits
      <>I   ;
      JC    OBJ1;
      L     4;
      JU    NOOB; //4 Objects in Tgrm
OBJ2: L     2;
      JU    NOOB; //2 Objects in Tgrm
OBJ1: L     1;
NOOB: T     #NoOfST1_Objects; //No of ST1-Obj., depending on Pack
      L     "BasicData".NofObjectItems2; //old number of objects in ref-list
      +I    ;
      T     "BasicData".NofObjectItems2; //new number of objects in ref-list

NETWORK
TITLE =
//Typical-Initialisation and basic settings.
M000: A     #OrgIndex_2_IN; //Object-DB is initialized ?
      JC    STRT;
      S     "BasicData".ObjRefListGen; //request for list generation
      A     #Enabled; //Typical is enabled ?
      S     #OrgIndex_2_FR; //set statusbit "Object is enabled"
      JC    PSET;
      S     #F3_S; //set "Object disabled" in Msg-header
      JU    PSET;
STRT: A     "BasicData".SystemStart; //System-Startup ?
      R     #OrgIndex_2_PF; //reset parameter error
      AN    "BasicData".SystemStart; //no System-Startup ?
      AN    #OrgIndex_2_PF; //no parameter error ?
      JC    M002;
      LAR1  P##OrgIndex_2_IN; //set pointer on INDEX_2 Word
      L     DIW [AR1,P#0.0]; //INDEX_2 in Akku 1
      L     2#1000011100000000; //mask on PF,..., SP, FR, IN
      AW    ;
      T     DIW [AR1,P#0.0]; //store INDEX_2
PSET: A     #TimeStamp; //Input: with Time-stamp ?
      =     #F3_Z; //set "with time-stamp" in Msg-header
      A     #Permanent; //Input: permanent transm. ?
      =     #F3_P; //set "permanent transm." in Msg-header
      L     P##MessageLen; //Pointer on first message byte
      SRW   3; //transform into Integervalue
      T     #SendMsgStartAddr; //preset Object-DB
      L     P##BinInfo_1_2; //Pointer on Data Index 0
      SRW   3; //transform into Integervalue
      T     #AddrDataIndex_0; //preset Object-DB
      L     P##OrgIndex_0_Bit_8; //Pointer on Org Index 0
      SRW   3; //transform into Integervalue
      T     #AddrOrgIndex_0; //preset Object-DB
      AN    #OrgIndex_2_IN;
      S     #OrgIndex_2_IN; //set statusbit "Object is initialized"
      LAR1  P##F4_Bit_0; //set pointer on F4-Array
      L     0;
      T     DIB [AR1,P#0.0]; //preset F4-Array with 0

NETWORK
TITLE =
//Preset Object-DB if system startup.
      L     0;
      L     #PartnerNo; //Destination
      ==I   ;
      JC    NOPA; //no specified communication partner
      SLD   16;
      T     #SearchPartner; //preset data for FC_SEARCH
      TAR1  #Save_AR1; //save AR1
      TAR2  #Save_AR2; //save AR2

      CALL "Search" (
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #SearchPartner,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #SearchRetVal);

      LAR1  #Save_AR1; //restore AR1
      LAR2  #Save_AR2; //restore AR2
      L     0;
      L     #SearchRetVal; //result of "SEARCH"
      <=D   ;
      JC    ADOK; //no error in "SEARCH", address = ok
      L     W#16#B101; //Error-ID: PartnerNo not found in Subscr. List
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //unknown Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ERR1: L     W#16#B100; //Error-ID: PartnerNo not valid
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //incorrect Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ADOK: T     #SubsRecStartAddr; //start-addr. in subscr. database
      R     #OrgIndex_2_PF; //reset parameter error
      L     #PartnerNo; //Input: Destination-partner-no
      T     #DestSubscrNo; //dest.-Partner-No in Msg
      L     1;
      T     #ParamNumbOfPartners; //param.  number of Partners
      JU    OBJT;
NOPA: A     #ReverseDirection; //operation in reverse direction ?
      JC    ERR1; //Error: PartnerNo = 0 and rev. Dir.
      R     #OrgIndex_2_PF; //reset parameter error
      L     0;
      T     #SubsRecStartAddr; //start-addr. in subscr. database
      T     #DestSubscrNo; //dest.-Partner-No in Msg
      T     #DestObjectNo; //dest-Object-No in Msg
      T     #ParamNumbOfPartners; //param.  number of Partners
OBJT: AN    #ReverseDirection; //no operation in reverse direction ?
      S     "BasicData".ObjRefListGen; //request for list generation
      AN    #F3_Z; //no time-stamp in message ?
      JC    NO_T;
      L     0;
      T     #Time_Stamp_1; //delete 1. part of time-stamp
      T     #Time_Stamp_2; //delete 2. part of time-stamp
NO_T: L     0;
      T     #SendReqFlags; //clear send-req-mask
      T     #DataLostFlags; //clear data-lost-mask
      T     #LinkErrorFlags; //clear link-error-mask
      T     #NumbOfRecvdBytes; //delete number of recvd bytes
      LAR1  P##OrgIndex_0_Bit_8; //Pointer on Org-Index 0
      T     DIW [AR1,P#0.0]; //delete ORG_INDEX_0 flags
      LAR1  P##IntNewSendReq_Data; //Pointer on internal Send-flags
      T     DIW [AR1,P#0.0]; //delete internal NEW_ and OLD_SendReq-flags

NETWORK
TITLE =
//Preset ST1-Parameters.
      L     0;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >=I   ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     250; //max. value for ST1_Message_No
      >I    ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      L     0;
      <I    ;
      JC    EROB; //Error in Object No.
      >I    ;
      JC    AE1; //ST1-Message with AE = 1
      L     2;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >I    ; //Message_No < 2 and Obj.-No < 1 ?
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      R     #F1_AE_1; //enter AE_ID = 0 into F1-Field
      R     #F1_AE_2; //    "          "          "
      L     0;
      T     #StartIndexNo; //preset Message
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE0R;
      T     #DestObjectNo; //preset Message
      L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
AE0R: L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #DestObjectNo; //preset Message;
      L     DINO; //local Object-No
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
AE1:  S     #F1_AE_1; //enter AE_ID = 1 into F1-Field
      R     #F1_AE_2; //    "          "          "
      L     255;
      L     #ST1_IndexNo; //read Input-parameter
      <I    ;
      JC    ERIN; //Error : Index_No > 255
      L     0;
      <I    ;
      JC    ERIN; //Error : Index_No < 0
      POP   ;
      SLW   1; //multiply with 2
      T     #StartIndexNo; //enter into Message-area
      L     #AddrDataIndex_0; //Start-Addr. DataIndex-0
      TAK   ;
      -I    ;
      T     #AddrDataIndex_0; //corrected Start-Addr. DataIndex-0
      SET   ; //******** ENTER PACK VALUE ********
      R     #F2_PACK_1; //clear Pack-Bit 1
      R     #F2_PACK_2; //clear Pack-Bit 2
      R     #F2_PACK_3; //clear Pack-Bit 3
      L     0; //Defaultvalue: 1 Obj. = 32Bit
      L     #ST1_PACK_Value; //Input-Parameter
      ==I   ;
      S     #F2_PACK_1; //set Pack-Bit 1
      S     #F2_PACK_2; //set Pack-Bit 2
      S     #F2_PACK_3; //set Pack-Bit 3
      JC    PKOK;
      L     8; //1 Object = 8 Bits
      ==I   ;
      S     #F2_PACK_1; //set Pack-Bit 1
      JC    PKOK;
      POP   ; //ST1_PACK_Value into Akku 1
      L     16; //1 Object = 16 Bits
      ==I   ;
      S     #F2_PACK_2; //set Pack-Bit 2
      JC    PKOK;
      POP   ;
      L     4; //1 Object = 4 Bits
      <>I   ;
      JC    ER12; //Error 12: Pack-Value not allowed
PKOK: L     255;
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      <I    ;
      JC    EROB; //Error: Object-No > 255
      L     #ST1_MessageNo; //Message_No for ST1-Message
      SLW   8; //Shift Message_No into High_Byte
      OW    ;
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE1R;
      T     #ST1MsgObjNo; //enter into Message-area
      L     0;
      T     #DestObjectNo;
      JU    M002;
AE1R: T     #DestObjectNo; //preset Message
      L     DINO; //local Object-No
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
ER10: L     W#16#B103; //Error-ID: ST1_Message_No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_MessageNo; //incorrect ST1-Message-No
      T     #DiagInfo_2;
      JU    PAFE;
EROB: L     W#16#B104; //Error-ID: Object-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_ObjectNo; //incorrect ST1-Object-No
      T     #DiagInfo_2;
      JU    PAFE;
ERIN: L     W#16#B105; //Error-ID: Index-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_IndexNo; //incorrect ST1-Index-No
      T     #DiagInfo_2;
      JU    PAFE;
ER12: L     W#16#B106; //Error-ID: PACK-Value not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_PACK_Value; //incorrect Pack-Value
      T     #DiagInfo_2;
      JU    PAFE;

NETWORK
TITLE =
//Entry in Object-Reference-List required ?
M002: ON    "BasicData".ObjRefListEntry; //enter item in ref-list ?
      O     #ReverseDirection; //reverse transmission mode ?
      JC    NXNW;
      L     "BasicData".DB_ObjectList2; //DB-No. Subscriber List 2
      T     #DBObjRefList; //store temporarily
      L     0;
      T     #ActValue; //temporary Object-Counter
      L     #NoOfST1_Objects; //1, 2 or 4 Objects in Tgrm
LOPL: T     #TempInt; //temporary loopcounter
      L     "BasicData".OwnSubscrNo; //local subscriber no
      OPN   DB [#DBObjRefList]; //open DB ObjRefList1
      L     DBW    0; //address of next free block
      SLD   3; //convert INT into pointer
      LAR1  ; //preset address-reg. 1
      POP   ; //transfer subscrNo into akku 1
      T     DBW [AR1,P#0.0]; //store in Ref.List
      L     #ST1MsgObjNo; //local input parameter
      L     #ActValue; //temporary Object-counter
      +I    ;
      T     DBW [AR1,P#2.0]; //store in Ref.List
      L     DINO; //local object No
      T     DBW [AR1,P#4.0]; //store in Ref.List
      L     DBW    0; //old address of next free block
      +     6; //add offset on next free block
      T     DBW    0; //new address of next free block
      L     #ActValue; //temporary Object-counter, old
      +     1;
      T     #ActValue; //temporary Object-Counter, new
      L     #TempInt; //temporary loopcounter
      LOOP  LOPL;

NETWORK
TITLE =
//Enable / disable Typical-Operation
NXNW: AN    #Enabled; //Typical is not enabled ?
      JC    DISA;
      O     #OrgIndex_2_FR; //Typical is already enabled ?
      O     #OrgIndex_2_SP; //Typical was disabled by ORG_Command ?
      JC    NXT1;
      S     #OrgIndex_2_FR; //set status "enabled"
      R     #F3_S; //reset Msg-header-info "disabled"
      S     #OrgIndex_0_EA; //set "single request"-command
NXT1: AN    #OrgIndex_0_BS; //no ORG-Command "disable Typical ?"
      JC    NXT2;
      R     #OrgIndex_0_BS; //reset disable-command
      R     #OrgIndex_2_FR; //reset status "enabled"
      S     #OrgIndex_2_SP; //set status "disabled by ORG-Commend"
      S     #F3_S; //set Msg-header-info "disabled"
      S     #OrgIndex_0_EA; //set "single request"-command
      JU    M003;
NXT2: AN    #OrgIndex_0_BF; //no ORG-Command "enable Typical" ?
      JC    M003;
      R     #OrgIndex_0_BF; //reset enable-command
      S     #OrgIndex_2_FR; //set status "enabled"
      R     #OrgIndex_2_SP; //reset status "disabled by ORG-Commend"
      R     #F3_S; //reset Msg-header-info "disabled"
      S     #OrgIndex_0_EA; //set "single request"-command
      JU    M003;
DISA: AN    #OrgIndex_2_FR; //Typical is already disabled ?
      JC    M003;
      R     #OrgIndex_2_FR; //reset status "enabled"
      R     #OrgIndex_2_SP; //reset status "disabled by ORG-Commend"
      S     #F3_S; //set Msg-header-info "disabled"
      S     #OrgIndex_0_EA; //set "single request"-command
      R     #OrgIndex_0_BS; //reset ORG-Command "disable Typical" ?
      R     #OrgIndex_0_BF; //reset ORG-Command "enable Typical" ?

NETWORK
TITLE =
//Process ORG_Command General Request.
M003: AN    "BasicData".GeneralRequest; //no Gen. Request Flag set ?
      JC    M004;
      L     #ParamNumbOfPartners; //No of param. Partners
      L     0;
      ==I   ;
      JC    NXT5;
      L     #SubsRecStartAddr; //Startaddress of Subs. Description
      L     "BasicData".OffsetRcvOrgIndex0;
      +I    ;
      SLD   3; //Pointerformeat
      LAR1  ; //preset Register Ar1
      AN    DBX [AR1,P#1.0]; //received ORG_INDEX_0_GA = 0 ?
      JC    M004;
NXT5: S     #OrgIndex_0_GA; //set General Request Command

NETWORK
TITLE =
//set EA if first Data transmission after "Time o.k.".
M004: L     0;
      T     #NumbOfRecvdBytes; //delete number of received Bytes
      ON    #F3_Z; //no time-stamp in Msg ?
      O(    ;
      AN    "BasicData".CpuClockOk; //Time of CPU-Clock is not yet ok ?
      AN    "BasicData".TimClockOk; //Time of TIM-Clock is not yet ok ?
      )     ;
      O     #OrgIndex_2_ZB; //"Time ok" already processed ?
      JC    PROC;
      S     #OrgIndex_0_EA; //set "single request"-command
      S     #OrgIndex_2_ZB; //set flag "Time ok" already processed

NETWORK
TITLE =
//SEND_REQUEST because of changed Process-Data.
PROC: AN    #OrgIndex_2_FR; //Typical is not enabled ?
      JC    M005;
      LAR1  P##InputByte_1; //Pointer on first Input-Byte
      L     DIW [AR1,P#0.0]; //read current 16 Bit Input-data
      L     #InversionMask; //read IN_parameter INVERSION_MASK
      XOW   ; //invert specified Input-Bits
      L     #DisableMask; //read IN-parameter DISABLE_MASK
      INVI  ;
      AW    ;
      LAR1  P##BinInfo_1_2; //Pointer on Data-Index 0
      A     "BasicData".SystemStart; //System-startup ?
      JC    NXT6; //Read Inputparam. and Process-Data
      L     DIW [AR1,P#0.0]; //load previous message image
      ==I   ;
      JC    M005; //no diff. between new and old value
      S     #IntNewSendReq_Data; //set INT_NEW_Send_Request_DATA
      POP   ; //transfer <akku2> into <akku1>
NXT6: T     DIW [AR1,P#0.0]; //store new message image

NETWORK
TITLE =
//process SEND_REQUEST for other reasons.
M005: AN    #F4_DS; //Data-transm. is not disabled ?
      JC    NXT8;
      R     #IntNewSendReq_Data; //clear new_transm_req for Proc_Data
NXT8: ON    #IntNewSendReq_Data; //no new_transm_req for Proc_Data ?
      O     #OrgIndex_2_EUE; //first transm. already done ?
      JC    M006;
      S     #OrgIndex_0_EA; //set "single request"-command

NETWORK
TITLE =
//Process send_req_flags
M006: L     #SendReqFlags; //transm._req_flags for FC_CREATE
      L     0;
      <>I   ;
      =     #SendReqFlag_0; //temp. flag
      LAR1  P##IntNewSendReq_Data; //Pointer on internal flags
      A     #OrgIndex_0_GA; //General Request command ?
      A     #OrgIndex_0_EA; //Single Request command ?
      R     #OrgIndex_0_EA; //reset Single Request command ?
      A     #OrgIndex_0_GA; //General Request command ?
      R     #OrgIndex_0_GA; //reset General Request command ?
      S     #IntNewSendReq_GA; //set internal NEW_SEND_REQUEST for GenReq
      R     #IntOldSendReq_EA; //reset internal OLD_SEND_REQUEST for SingleReq
      JC    NX10;
      AN    #OrgIndex_0_EA; //no Single Request command ?
      JC    NX11;
      R     #OrgIndex_0_EA; //reset Single Request command ?
      AN    #IntOldSendReq_GA; //no old_GA_req present ?
      S     #IntNewSendReq_EA; //set internal NEW_SEND_REQUEST for SingleReq
NX10: AN    #OrgIndex_2_EUE; //first transm. not yet processed ?
      S     #OrgIndex_2_EUE; //set flag "first transm. processed"
NX11: A     #IntNewSendReq_Data; //new_transm_req for Proc_Data ?
      JC    M007;
      O     #IntNewSendReq_GA; //IntNewSendReq_GA ?
      O     #IntNewSendReq_EA; //IntNewSendReq_EA ?
      JC    NX12;
      AN    #SendReqFlag_0; //no send request present ?
      BEC   ;
      L     DIB [AR1,P#1.0]; //old internal TX-Req
      T     DIB [AR1,P#0.0]; //new internal TX-Req
      JU    M011;
NX12: AN    #SendReqFlag_0; //no send request present ?
      JC    M008;
      L     DIB [AR1,P#1.0]; //old internal TX-Req
      L     DIB [AR1,P#0.0]; //new internal TX-Req
      OW    ;
      T     DIB [AR1,P#0.0]; //new internal TX-Req
      AN    #F3_PR; //last Msg transm. as Image-Memory-Msg ?
      JC    M008;
      L     1;
      T     #SendReqFlags; //Send-Req for FC_CREATE (1 partner)
      S     #F3_TA_1; //Preset TA with 3
      S     #F3_TA_2; //Preset TA with 3
      JU    M011;
M007: AN    #SendReqFlag_0; //no send request present ?
      JC    M008;
      ON    #F3_PR; //last Msg transm. as Image-Memory-Msg ?
      ON    #IntOldSendReq_Data; //old internal SEND_REQUEST for Data ?
      JC    NX13;
      L     #SendReqFlags; //SEND-Req-Flags for FC_CREATE
      L     #DataLostFlags;
      OW    ;
      T     #DataLostFlags;
NX13: L     DIB [AR1,P#1.0]; //old internal TX-Req
      L     DIB [AR1,P#0.0]; //new internal TX-Req
      OW    ;
      T     DIB [AR1,P#0.0]; //new internal TX-Req

NETWORK
TITLE =
//Prepare message for entry into Send-buffer.
M008: AN    #F3_Z; //no time-stamp in message ?
      JC    NX15;
      AN    "BasicData".CpuClockOk; //CPU-Clock not ok ?
      JC    NX16;
      L     DBD    0; //BasicData, current Time, part 1
      T     #Time_Stamp_1; //write into message
      L     DBD    4; ///BasicData, current Time, part 2
      T     #Time_Stamp_2; //write into message
      JU    NX15;
NX16: AN    "BasicData".TimClockOk; //TIM-Clock not ok ?
      R     #OrgIndex_2_ZB; //reset flag Msg sent after "time ok"
      L     0;
      T     #Time_Stamp_1; //delete 1. Part of time-stamp
      T     #Time_Stamp_2; //delete 2. Part of time-stamp
NX15: L     1;
      T     #SendReqFlags; //Send-Req for FC_CREATE (1 partner)
      L     0;
      T     #NumbOfBytesToSend;
      LAR1  P##IntNewSendReq_Data; //pointer on internal NEW_Send_Request-Byte
      L     DIB [AR1,P#0.0]; //internal NEW_Send_Request-Byte
      L     DIB [AR1,P#1.0]; //internal OLD_Send_Request-Byte
      OW    ;
      T     DIB [AR1,P#0.0]; //internal NEW_Send_Request-Byte
      AN    #IntNewSendReq_Data; //new internal Send_Request_DATA ?
      AN    #IntNewSendReq_EA; //new internal Send_Request_EA ?
      R     #F3_U; //reset F3-Message-Header
      R     #F3_B; //reset F3-Message-Header
      JC    NX17;
      A     #Conditional; //Input Parameter
      S     #F3_B; //Preset F3-Message-Header
      A     #Unconditional; //Input Parameter
      S     #F3_U; //Preset F3-Message-Header
NX17: O     #IntNewSendReq_GA; //new internal SEND_REQUEST_GA ?
      O     #IntNewSendReq_EA; //new internal SEND_REQUEST_EA ?
      JC    NX18;
      R     #F3_TA_1; //Preset TA with 2
      S     #F3_TA_2; //Preset TA with 2
      JU    SET;
NX18: S     #F3_TA_1; //Preset TA with 3
      S     #F3_TA_2; //Preset TA with 3
SET:  AN    #ImageMemory; //Input Parameter
      =     #F3_PR; //Preset F3-Message-Header
      L     2;
      T     #NumbOfBytesToSend; //Preset Message

NETWORK
TITLE =
//Call FC_CREATE, to enter message into DB_Com.
M011: TAR2  #Save_AR2; //save AR2
      CALL "Create" (
           SubscriberObject         := FALSE);
      LAR2  #Save_AR2; //restore AR2

NETWORK
TITLE =
//Process internal Send_Request_Flags.
      LAR1  P##IntNewSendReq_Data; //set pointer on internal flags
      L     #SendReqFlags; //Send_Req_Flags for FC_CREATE
      L     0;
      ==I   ;
      JC    TXOK;
      L     #LinkErrorFlags; //Link_Error_Flags from FC _CREATE
      L     #SendReqFlags; //Send_Req_Flags for FC_CREATE
      <>I   ;
      JC    CHK1;
      A     #OrgIndex_0_GA; //command for General Request ?
      R     #OrgIndex_0_GA; //reset command for General Request
      JC    COPY;
      AN    DIX [AR1,P#0.2]; //no INT_NEW_GA -Bit ?
      JC    COPY;
      R     DIX [AR1,P#0.2]; //reset INT_NEW_GA -Bit
      A     DIX [AR1,P#0.0]; //INT_NEW_DATA  -Bit ?
      JC    COPY;
      L     0;
      T     #SendReqFlags; //clear all Send_Req_Flags for FC_CREATE
      JU    M011; //call FC_CREATE
CHK1: O     #OrgIndex_0_GA; //command for General Request ?
      O     #IntNewSendReq_GA; //internal new Send-Req for GenReq ?
      S     "BasicData".DelayGenReqEnd; //global flag to delay GenReqEnd
COPY: L     DIB [AR1,P#0.0]; //INT_NEW_SEND_Flags
      T     DIB [AR1,P#1.0]; //store to INT_OLD_SEND_Flags
      L     0;
      T     DIB [AR1,P#0.0]; //clear all NEW_SEND_Flags
      BEU   ;
TXOK: T     DIW [AR1,P#0.0]; //clear all NEW_ and OLD_SEND_Flags
      BEU   ;

NETWORK
TITLE =
//Enter errormessage in diagnosis-buffer.
PAFE: S     "BasicData".ParameterError; //set global Error flag
      A     #OrgIndex_2_PF; //parameter error is already set
      BEC   ; // ***** END *****
      S     #OrgIndex_2_PF;

      CALL "WR_USMSG" (
           SEND                     := TRUE,//enter error message in diagnosis buffer
           EVENTN                   := #DiagID,
           INFO1                    := #DiagInfo_1,
           INFO2                    := #DiagInfo_2,
           RET_VAL                  := #TempInt);


END_FUNCTION_BLOCK

//_____________________________________________________________________________________________

FUNCTION_BLOCK "MTA01"
TITLE = MTA01
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : MTA01
VERSION : 1.1


VAR_INPUT
  PartnerNo : INT ;	//Subscriber-No. of communication-partner
  ST1_MessageNo : INT ;	//ST1-Message-No:	1...250;
  ST1_ObjectNo : INT ;	//ST1-Object-No:	0 or 1...250;
  ST1_IndexNo : INT ;	//ST1-Index-No:	0...255;
  Enabled : BOOL  := TRUE;	//Enable Functionblock
  ReverseDirection : BOOL ;	//reverse transm.-direction for ST1-Messages
END_VAR
VAR_OUTPUT
  OutputByte_1 : BYTE ;	//Binary-Info-Destination-Byte 1
  OutputByte_2 : BYTE ;	//Binary-Info-Destination-Byte 2
  OutputByte_3 : BYTE ;	//Binary-Info-Destination-Byte 3
  OutputByte_4 : BYTE ;	//Binary-Info-Destination-Byte 4
  NewData : BOOL ;	//New data received
END_VAR
VAR
  MessageLen : BYTE ;	//Msg_Header_Byte_1: Msg-Length in Bytes
  F1_Bit_0 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 0 = 0
  F1_AE_1 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 1 = AE (2 exp 0)
  F1_AE_2 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 2 = AE (2 exp 1)
  F1_FA : BOOL  := TRUE;	//Msg_Header_Byte_2: F1: Bit 3 = FA: Function Select (TIM / CPU)
  F1_Bit_4 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 4 = 0
  F1_Bit_5 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 5 = 0
  F1_Bit_6 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 6 = 0
  F1_Bit_7 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 7 = 0
  F2_Bit_0 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 0 = 0
  F2_Bit_1 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 1 = 0
  F2_Bit_2 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 2 = 0
  F2_Bit_3 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 3 = 0
  F2_X : BOOL  := TRUE;	//Msg_Header_Byte_3: F2: Bit 4 = X: Msg to be deleted on link-error
  F2_Bit_5 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 5 = 0
  F2_Bit_6 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 6 = 0
  F2_Bit_7 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 7 = 0
  F3_PR : BOOL  := TRUE;	//Msg_Header_Byte_4: F3: Bit 0: PR = 0/1 = image-mem / send-buffer
  F3_Bit_1 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 1 = 0
  F3_U : BOOL  := TRUE;	//Msg_Header_Byte_4: F3: Bit 2: U = 1: unconditional transm.
  F3_Bit_3 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 3 = 0
  F3_Bit_4 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 4 = 0
  F3_S : BOOL ;	//Msg_Header_Byte_4: F3: Bit 5: S = 1: Object is disabled
  F3_TA_1 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 6: TA (2 exp 0)
  F3_TA_2 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 7: TA (2 exp 1)
  F4_Bit_0 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 0 = 0
  F4_Bit_1 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 1 = 0
  F4_Bit_2 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 2 = 0
  F4_Bit_3 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 3 = 0
  F4_Bit_4 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 4 = 0
  F4_Bit_5 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 5 = 0
  F4_DS : BOOL ;	//Msg_Header_Byte_5: F4: Bit 6: DS = Data-transm. is disabled (not valid)
  F4_DV : BOOL ;	//Msg_Header_Byte_5: F4: Bit 7: DV = Data lost  (not valid)
  MsgHeaderByte_6 : BYTE  := B#16#12;	//Msg_Header_Byte_6: number of dest. / Len of Dest-Addr. = 2 Bytes
  DestSubscrNo : INT ;	//Destination-Subscr.-No
  ST1MsgObjNo : INT ;	//ST1-Msg-No (AE=0) / ST1-Msg-No : ST1-Obj-No (AE=1)
  SourceObjectNo : INT ;	//Source-Object-No = current Instance-DB
  StartIndexNo : INT ;	//Start-Index-No
  BinInfoByte_1_2 : WORD ;	//DATA_INDEX_0: received Binary-Info-Byte 1 and 2
  BinInfoByte_3_4 : WORD ;	//DATA_INDEX_2: received Binary-Info-Byte 3 and 4
  OrgIndex_0_Bit_8 : BOOL ;	//ORG_INDEX_0, Bit 8:
  OrgIndex_0_Bit_9 : BOOL ;	//ORG_INDEX_0, Bit 9:
  OrgIndex_0_Bit_10 : BOOL ;	//ORG_INDEX_0, Bit 10:
  OrgIndex_0_Bit_11 : BOOL ;	//ORG_INDEX_0, Bit 11:
  OrgIndex_0_Bit_12 : BOOL ;	//ORG_INDEX_0, Bit 12:
  OrgIndex_0_Bit_13 : BOOL ;	//ORG_INDEX_0, Bit 13:
  OrgIndex_0_Bit_14 : BOOL ;	//ORG_INDEX_0, Bit 14:
  OrgIndex_0_UEA : BOOL ;	//ORG_INDEX_0, Bit 15: param.-transm. request (not valid)
  OrgIndex_0_GA : BOOL ;	//ORG_INDEX_0, Bit 0: GA = general request (not valid)
  OrgIndex_0_EA : BOOL ;	//ORG_INDEX_0, Bit 1: EA = single request
  OrgIndex_0_Bit_2 : BOOL ;	//ORG_INDEX_0, Bit 2:
  OrgIndex_0_Bit_3 : BOOL ;	//ORG_INDEX_0, Bit 3: .
  OrgIndex_0_Bit_4 : BOOL ;	//ORG_INDEX_0, Bit 4:
  OrgIndex_0_Bit_5 : BOOL ;	//ORG_INDEX_0, Bit 5:
  OrgIndex_0_BS : BOOL ;	//ORG_INDEX_0, Bit 6: BS = disable operation (only valid if AE=0)
  OrgIndex_0_BF : BOOL ;	//ORG_INDEX_0, Bit 7: BF = enable operation (only valid if AE=0)
  OrgIndex_2_IN : BOOL ;	//ORG_INDEX_2, Bit 8: IN = Object-DB is initialized
  OrgIndex_2_FR : BOOL ;	//ORG_INDEX_2, Bit 9: FR = Object is enabled
  OrgIndex_2_Bit_10 : BOOL ;	//ORG_INDEX_2, Bit 10:
  OrgIndex_2_Bit_11 : BOOL ;	//ORG_INDEX_2, Bit 11:
  OrgIndex_2_Bit_12 : BOOL ;	//ORG_INDEX_2, Bit 12:
  OrgIndex_2_Bit_13 : BOOL ;	//ORG_INDEX_2, Bit 13:
  OrgIndex_2_Bit_14 : BOOL ;	//ORG_INDEX_2, Bit 14:
  OrgIndex_2_PF : BOOL ;	//ORG_INDEX_2, Bit 15: PF = parameter error
  OrgIndex_2_A : BOOL ;	//ORG_INDEX_2, Bit 0: A= 0/1: received data not ok/ ok
  OrgIndex_2_GL : BOOL ;	//ORG_INDEX_2, Bit 1: GA=0/1: no GenReq active/ GenReq active
  OrgIndex_2_EL : BOOL ;	//ORG_INDEX_2, Bit 2: EA=0/1: no SingleReq active/ SingleReq active
  OrgIndex_2_AF : BOOL ;	//ORG_INDEX_2, Bit 3: AF=0/1: no Req error/ Req error for last Req
  OrgIndex_2_DF : BOOL ;	//ORG_INDEX_2, Bit 4: DF=0/1: no error/error on last Data-send job (not valid)
  OrgIndex_2_OF : BOOL ;	//ORG_INDEX_2, Bit 5: OF=0/1: no error/error on last Org-send job
  OrgIndex_2_Bit_6 : BOOL ;	//ORG_INDEX_2, Bit 6:
  OrgIndex_2_Bit_7 : BOOL ;	//ORG_INDEX_2, Bit 7:
  OrgIndex_4_PR : BOOL ;	//ORG_INDEX_4, Bit 8: PR = remote Object, transm. principle
  OrgIndex_4_B : BOOL ;	//ORG_INDEX_4, Bit 9:  B = remote Object, conditional transm.
  OrgIndex_4_U : BOOL ;	//ORG_INDEX_4, Bit 10: U = remote Object, unconditional transm.
  OrgIndex_4_P : BOOL ;	//ORG_INDEX_4, Bit 11: P = remote Object, permanent transm.
  OrgIndex_4_Z : BOOL ;	//ORG_INDEX_4, Bit 12: B = remote Object, with time-stamp
  OrgIndex_4_S : BOOL ;	//ORG_INDEX_4, Bit 13: S = remote Object, Operation is disabled
  OrgIndex_4_TA_1 : BOOL ;	//ORG_INDEX_4, Bit 14: TA (2 exp 0) of last remote Object Message
  OrgIndex_4_TA_2 : BOOL ;	//ORG_INDEX_4, Bit 15: TA (2 exp 1) of last remote Object Message
  OrgIndex_4_Bit_0 : BOOL ;	//ORG_INDEX_4, Bit 0:
  OrgIndex_4_Bit_1 : BOOL ;	//ORG_INDEX_4, Bit 1:
  OrgIndex_4_Bit_2 : BOOL ;	//ORG_INDEX_4, Bit 2:
  OrgIndex_4_Bit_3 : BOOL ;	//ORG_INDEX_4, Bit 3:
  OrgIndex_4_Bit_4 : BOOL ;	//ORG_INDEX_4, Bit 4:
  OrgIndex_4_Bit_5 : BOOL ;	//ORG_INDEX_4, Bit 5:
  OrgIndex_4_Bit_6 : BOOL ;	//ORG_INDEX_4, Bit 6:
  OrgIndex_4_Bit_7 : BOOL ;	//ORG_INDEX_4, Bit 7:
  RecTimeStamp_1 : DWORD ;	//Time_Stamp: Year, Month, Day, Hour
  RecTimeStamp_2 : DWORD ;	//Time_Stamp: Minute, Second, MSec*10, MSec*1/Status
  IntNewSendReq_Cmd : BOOL ;	//New Send-Request for Commands
  IntNewSendReq_Param : BOOL ;	//New Send-Request for Parameters (not valid)
  IntNewSendReq_Org0 : BOOL ;	//New Send-Request for OrgIndex_0
  IntNewSendReq_spare : BOOL ;	//Spare
  IntNewSendReq_spare_1 : BOOL ;	//Spare
  IntNewSendReq_spare_2 : BOOL ;	//Spare
  IntNewSendReq_spare_3 : BOOL ;	//Spare
  IntNewSendReq_spare_4 : BOOL ;	//Spare
  IntOldSendReq_Cmd : BOOL ;	//Old Send-Request for Commands
  IntOldSendReq_Param : BOOL ;	//Old Send-Request for Parameters (not valid)
  IntOldSendReq_Org0 : BOOL ;	//Old Send-Request for OrgIndex_0
  IntOldSendReq_spare : BOOL ;	//Spare
  IntOldSendReq_spare_1 : BOOL ;	//Spare
  IntOldSendReq_spare_2 : BOOL ;	//Spare
  IntOldSendReq_spare_3 : BOOL ;	//Spare
  IntOldSendReq_spare_4 : BOOL ;	//Spare
  SupvTimeEA : INT ;	//supervisison timer (s) for Single Request
  SubsRecStartAddr : WORD ;	//Start-address of data-record in subscriber-database
  MaxNumbOfPartners : BYTE  := B#16#1;	//SEND_POINTER: max. number of partners
  ParamNumbOfPartners : BYTE  := B#16#1;	//SEND_POINTER: parametr. number of partners
  SendMsgStartAddr : WORD ;	//SEND_POINTER: Start-address of send-message
  NumbOfBytesToSend : BYTE  := B#16#2;	//SEND_POINTER: number of bytes to send, starting with Start Index No
  LinkErrorFlags : BYTE ;	//SEND_POINTER: Link error flags to partner
  SendReqFlags : BYTE ;	//SEND_POINTER: Send-request-flags to Partner
  DataLostFlags : BYTE ;	//SEND_POINTER: Flags to indicate lost messages to partner
  AddrDataIndex_0 : WORD ;	//BASE_POINTER: Address of DATA-INDEX-0
  AddrOrgIndex_0 : WORD ;	//BASE_POINTER: Address of ORG-INDEX-0
  NumbOfRecvdBytes : BYTE ;	//BASE_POINTER: number of received Bytes in last recv. message
  MaxRecvDataBytes : BYTE  := B#16#4;	//BASE_POINTER: number of max. possible recv. data-bytes
  ST7_ID : BYTE  := B#16#A5;	//BASE_POINTER: SINAUT ST7 Object-DB-ID = A5
  LastByte_SZ : BOOL  := TRUE;	//BASE_POINTER: Last-Byte: SZ = 1: send-pointers available
  LastByte_EA : BOOL ;	//BASE_POINTER: Last-Byte: EA = 1: space for receive addresses (not valid)
  LastByte_EZ : BOOL  := TRUE;	//BASE_POINTER: Last-Byte: EZ = 1: space for receive time stamp
  LastByte_Bit_3 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 3:
  LastByte_Bit_4 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 4:
  LastByte_Bit_5 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 5:
  LastByte_Bit_6 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 6:
  LastByte_Bit_7 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 7:
END_VAR
VAR_TEMP
  SearchPartner : DWORD ;
  SearchRetVal : DWORD ;
  DiagID : WORD ;
  DiagInfo_1 : WORD ;
  DiagInfo_2 : DWORD ;
  DBObjRefList : WORD ;
  PointRcvOrgIndex : DWORD ;
  PointSendOrgIndex : DWORD ;
  TempInt : INT ;
  Save_AR1 : DWORD ;
  Save_AR2 : DWORD ;
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!
RUN:  NOP   0;
NETWORK
TITLE =
//Create Object Reference List ?
      AN    "BasicData".ObjRefListLen; //prepare ref-list-generation
      JC    M000;
      L     "BasicData".NofObjectItems1; //old number of objects in ref-list
      +     1;
      T     "BasicData".NofObjectItems1; //new number of objects in ref-list
NETWORK
TITLE =
//Typical-Initialisation and basic settings.
M000: LAR1  P##OrgIndex_0_Bit_8; //set pointer on ORG_INDEX_0 Word
      A     #OrgIndex_2_IN; //Object-DB is initialized ?
      JC    STRT;
      S     "BasicData".ObjRefListGen; //request for list generation
      A     #Enabled; //Typical is enabled ?
      S     #OrgIndex_2_FR; //set statusbit "Object is enabled"
      JC    PSET;
      S     #F3_S; //set "Object disabled" in Msg-header
      JU    PSET;
STRT: A     "BasicData".SystemStart; //System-Startup ?
      R     #OrgIndex_2_PF; //reset No error ?
      AN    "BasicData".SystemStart; //System-Startup ?
      AN    #OrgIndex_2_PF; //no No error ?
      JC    M002;
      L     DIW [AR1,P#2.0]; //ORG_INDEX_2 in Akku 1
      L     2#1000001100000000; //mask on PF,..., FR, IN
      AW    ;
      T     DIW [AR1,P#2.0]; //store ORG_INDEX_2
PSET: L     P##MessageLen; //Pointer on first message byte
      SRW   3; //transform into Integervalue
      T     #SendMsgStartAddr; //preset Object-DB
      L     P##BinInfoByte_1_2; //Pointer on Data Index 0
      SRW   3; //transform into Integervalue
      T     #AddrDataIndex_0; //preset Object-DB
      L     P##OrgIndex_0_Bit_8; //set pointer on ORG_INDEX_0
      SRW   3; //transform into Integervalue
      T     #AddrOrgIndex_0; //preset Object-DB
      AN    #OrgIndex_2_IN;
      S     #OrgIndex_2_IN; //set statusbit "Object is initialized"
      LAR1  P##F4_Bit_0; //set pointer on F4-Array
      L     0;
      T     DIB [AR1,P#0.0]; //preset F4-Array with 0
NETWORK
TITLE =
//Preset Object-DB if system startup.
      L     0;
      L     #PartnerNo; //Destination
      >=I   ;
      JC    ERR1; //Error 1: Partner No or Obj.-No not correct
      SLD   16;
      T     #SearchPartner; //preset data for FC_SEARCH
      TAR1  #Save_AR1; //save AR1
      TAR2  #Save_AR2; //save AR2
      CALL "Search" (
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #SearchPartner,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #SearchRetVal);
      LAR1  #Save_AR1; //restore AR1
      LAR2  #Save_AR2; //restore AR2
      L     0;
      L     #SearchRetVal; //result of "SEARCH"
      <=D   ;
      JC    ADOK; //no error in "SEARCH", address = ok
      L     W#16#B101; //Error-ID: PartnerNo not found in Subscr. List
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //unknown Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ERR1: L     W#16#B100; //Error-ID: PartnerNo not valid
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //incorrect Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ADOK: T     #SubsRecStartAddr; //start-addr. in subscr. database
      R     #OrgIndex_2_PF; //reset No error
      S     "BasicData".ObjRefListGen; //request for list generation
      L     #PartnerNo; //Input: Destination-partner-No
      T     #DestSubscrNo; //dest.-Partner-No in Msg
      L     1;
      T     #ParamNumbOfPartners; //param.  No of Partners
      L     0; //
      T     #SendReqFlags; //clear send-req-mask
      T     #DataLostFlags; //clear data-lost-mask
      T     #LinkErrorFlags; //clear link-error-mask
      T     #NumbOfRecvdBytes; //delete number of recvd bytes
      LAR1  P##OrgIndex_0_Bit_8; //Pointer on Org-Index 0
      T     DIW [AR1,P#0.0]; //delete ORG_INDEX_0 flags
      LAR1  P##IntNewSendReq_Cmd; //Pointer on internal Send-flags
      T     DIW [AR1,P#0.0]; //delete internal NEW_ and OLD_SendReq-flags
NETWORK
TITLE =
//Preset ST1-Parameters.
      L     0;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >=I   ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     250; //max. value for ST1_Message_No
      >I    ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      L     0;
      <I    ;
      JC    EROB; //Error in Object No.
      >I    ;
      JC    AE1; //ST1-Message with AE = 1
      L     2;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >I    ; //Message_No < 2 and Obj.-No < 1 ?
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      R     #F1_AE_1; //enter AE_ID = 0 into F1-Field
      R     #F1_AE_2; //    "          "          "
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE0R;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #ST1MsgObjNo; //preset Message
      L     DINO; //local Object No
      T     #SourceObjectNo; //preset message
      JU    M002;
AE0R: L     0;
      T     #ST1MsgObjNo; //preset message;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #SourceObjectNo; //preset message
      JU    M002;
AE1:  S     #F1_AE_1; //enter AE_ID = 1 into F1-Field
      R     #F1_AE_2; //    "          "          "
      L     255;
      L     #ST1_IndexNo; //Input Parameter
      <I    ;
      JC    ERIN;
      L     0;
      <I    ;
      JC    ERIN; //Error : Index_No < 0
      POP   ;
      SLW   1; //multiply with 2
      L     #AddrDataIndex_0; //Start-Addr. Data-Index 0
      TAK   ;
      -I    ;
      T     #AddrDataIndex_0; //preset base-pointer
      L     255;
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      <I    ;
      JC    EROB;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      SLW   8; //Shift Message_No into High_Byte
      OW    ;
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE1R;
      T     #ST1MsgObjNo; //enter into message-area
      L     DINO; //local Object No
      T     #SourceObjectNo; //enter into message-area
      JU    M002;
AE1R: T     #SourceObjectNo; //preset message
      L     0;
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
ER10: L     W#16#B103; //Error-ID: ST1_Message_No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_MessageNo; //incorrect ST1-Message-No
      T     #DiagInfo_2;
      JU    PAFE;
EROB: L     W#16#B104; //Error-ID: Object-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_ObjectNo; //incorrect ST1-Object-No
      T     #DiagInfo_2;
      JU    PAFE;
ERIN: L     W#16#B105; //Error-ID: Index-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_IndexNo; //incorrect ST1-Index-No
      T     #DiagInfo_2;
      JU    PAFE;
NETWORK
TITLE =
//Entry in Object Reference List required ?
M002: AN    "BasicData".ObjRefListEntry; //enter item in ref-list ?
      JC    NXNW;
      L     "BasicData".DB_ObjectList1; //DB-No. Subscriber List 1
      T     #DBObjRefList; //store temporarily
      OPN   DB [#DBObjRefList]; //open DB ObjRefList1
      L     DBW    0; //address of next free block
      SLD   3; //convert INT into pointer
      LAR1  ; //preset address-reg. 1
      L     #PartnerNo; //No. of comm.-partner
      AN    #ReverseDirection; //no operation in rev. Dir. ?
      JC    NORM;
      L     "BasicData".OwnSubscrNo; //local Subscriber No
      OPN   DB [#DBObjRefList]; //open DB ObjRefList1
NORM: T     DBW [AR1,P#0.0]; //store in Ref.List
      L     #ST1MsgObjNo; //local input parameter
      AN    #ReverseDirection; //no reverse transmission mode ?
      JC    STOR;
      L     #SourceObjectNo; //
STOR: T     DBW [AR1,P#2.0]; //store in Ref.List
      L     DINO; //local object No
      T     DBW [AR1,P#4.0]; //store in Ref.List
      L     DBW    0; //old address of next free block
      +     6; //add offset on next free block
      T     DBW    0; //new address of next free block
NETWORK
TITLE =
//Enable / disable Typical-Operation ?
NXNW: AN    #Enabled; //Object is not enabled ?
      JC    DISA;
      AN    #OrgIndex_2_FR; //statusflag "enabled" is not set ?
      S     #OrgIndex_2_FR; //set statusflag
      S     #OrgIndex_0_EA; //set single req. command
      R     #F3_S; //reset flag in Msg-header
      JU    CYCL;
DISA: R     #OrgIndex_2_FR; //reset statusflag
      S     #F3_S; //set flag in Msg-header
NETWORK
TITLE =
//Process GA-Start-Bit
CYCL: L     #SubsRecStartAddr; //address of Subscr. Record in BasicData
      L     "BasicData".OffsetSendOrgIndex0; //offset on Send-Index in Subscr.-Rec.
      +D    ;
      SLD   3; //transform into pointer
      T     #PointSendOrgIndex; //store Pointer temporarily
      L     #SubsRecStartAddr; //address of Subscr. Record in BasicData
      L     "BasicData".OffsetRcvOrgIndex0; //offset on Receive-Index in Subscr.-Rec.
      +D    ;
      SLD   3; //transform into pointer
      T     #PointRcvOrgIndex; //store Pointer temporarily
      LAR1  ; //load AR1 with address of Recv.-Index 0
      A     DBX [AR1,P#3.1]; //GA-Start-Bit in Recv.-Index 2 is set ?
      S     #OrgIndex_2_GL; //set status "GenReq is active"
NETWORK
TITLE =
//Basic processing of received message
      L     #NumbOfRecvdBytes; //********************************
      L     0; //number of received bytes = 0 ? =>
      ==I   ; //   no new message received
      R     #NewData; //
      JC    SUPV; //
      S     #NewData; //
      T     #NumbOfRecvdBytes; //********************************
      A     #OrgIndex_4_TA_2; //TA = 2: received message =
      AN    #OrgIndex_4_TA_1; //        normal data message ?
      JC    RESA; //********************************
      AN    #OrgIndex_4_S; //remote Object is not disabled ?
      AN    #OrgIndex_2_GL; //no GenReq is active ?
      AN    #OrgIndex_2_EL; //no SingleReq is active ?
      S     #OrgIndex_2_A; //set status "received data valid"
      O     #OrgIndex_2_GL; //GenReq is active ?
      O     #OrgIndex_2_EL; //SingleReq is active ?
      R     #OrgIndex_2_GL; //reset GenReq status-bit
      R     #OrgIndex_2_EL; //reset SingleReq status-bit
      R     #OrgIndex_2_AF; //reset Request-error status-bit
      S     #OrgIndex_2_A; //set status "received data valid"
RESA: ON    #OrgIndex_2_FR; //local Object is not enabled ?
      O     #OrgIndex_4_S; //remote Object is disabled ?
      R     #OrgIndex_2_A; //reset status "received data valid"
NETWORK
TITLE =
//General-/Single-request supervision.
SUPV: AN    DBX [AR1,P#5.0]; //Status "Partner is not o.k." (BasicData) ?
      R     #OrgIndex_2_A; //reset status "data valid"
      AN    #OrgIndex_2_GL; //GenReq is not active ?
      JC    SREQ;
      LAR1  #PointSendOrgIndex; //set AR1 on Send-Index 0 in BasicData
      S     DBX [AR1,P#5.3]; //set "GenReq incomplete" in Subscr.-Rec.
      LAR1  #PointRcvOrgIndex; //set AR1 on Receive-Index 0 in BasicData
      AN    DBX [AR1,P#3.2]; //GA-End-Bit in Recv.-Index 2 is not set ?
      JC    SREQ;
      R     #OrgIndex_2_GL; //reset GenReq status-bit
      S     #OrgIndex_2_AF; //set Request-error status-bit
      R     #OrgIndex_2_A; //reset status "received data valid"
      L     W#16#B162; //Error-ID: GA not correctly terminated
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //Dest.-Subscriber-No
      T     #DiagInfo_2;
      JU    ENTR;
SREQ: ON    #OrgIndex_2_EL; //SingleReq is not active ?
      ON    "BasicData".Pulse_1s; //1-s-Pulse is not active ?
      JC    OUTP;
      L     #SupvTimeEA; //Single request supervision timer, old
      +     -1; //decrement timer
      T     #SupvTimeEA; //Single request supervision timer, new
      L     0;
      >I    ;
      JC    OUTP; //Single Request still running, timer > 0
      R     #OrgIndex_2_EL; //reset Status "single request running"
      R     #OrgIndex_2_A; //reset Status "received data valid"
      S     #OrgIndex_2_AF; //set Status "request error"
      L     W#16#B163; //Error-ID: EA not correctly terminated
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //Dest.-Subscriber-No
      T     #DiagInfo_2;
      JU    ENTR;
NETWORK
TITLE =
//Write received Binary-Info-bytes to output-addresses.
OUTP: ON    #OrgIndex_2_FR; //Typical is not enabled ?
      ON    #NewData; //no new data received ?
      JC    ORG0;
      LAR1  P##BinInfoByte_1_2; //Pointer on received binary info bytes
      L     DID [AR1,P#0.0]; //receiced binary info, 32 Bit
      LAR1  P##OutputByte_1; //Pointer on Output-addresses
      T     DID [AR1,P#0.0]; //write 32 Bit binary info to outputs
NETWORK
TITLE =
//Start and monitor Org Index 0 transmission.
ORG0: LAR1  P##OrgIndex_0_Bit_8; //Pointer on Org-Index-0 Word
      O     #F1_AE_1; //AE is not 0 ?
      O     #F1_AE_2; //AE is not 0 ?
      R     #OrgIndex_0_BF; //reset Org-Command "enable operation" ?
      R     #OrgIndex_0_BS; //reset Org-Command "disable operation" ?
      A     #OrgIndex_0_BF; //Org-Command "enable operation" ?
      S     #OrgIndex_0_EA; //Org-Command "single request command"
      L     DIW [AR1,P#0.0]; //Index_0 into Akku 1
      L     2#11000010; //mask on BF,BS and EA
      AW    ;
      T     DIW [AR1,P#0.0]; //restore Index_0
      L     0;
      ==I   ; //no new Job in Org_Index_0 ?
      AN    #IntNewSendReq_Org0; //************************************
      BEC   ; //
      S     #IntNewSendReq_Org0; //set internal flag "Send-Job started"
      L     1; //* PRESET SEND_AREA IN OBJECT_DB !  *
      T     #SendReqFlags; //* set send-flag 0 for FC_CREATE    *
      TAR2  #Save_AR2; //save AR2
      CALL "Create" (
           SubscriberObject         := FALSE);
      LAR2  #Save_AR2; //restore AR2
      LAR1  P##SendReqFlags; //set pointer on send-request flags
      A     DIX [AR1,P#0.0]; //SendReqFlag is still set ?
      BEC   ;
      R     #IntNewSendReq_Org0; //reset internal flag "Send-Job started"
      A     #OrgIndex_0_EA; //single request command ?
      A     #OrgIndex_2_OF; //error on Org Index transmission ?
      S     #OrgIndex_2_AF; //set status "error on last request answer"
      R     #OrgIndex_2_A; //reset status "received data valid"
      ON    #OrgIndex_0_EA; //no single request command ?
      O     #OrgIndex_2_OF; //error on Org Index transmission ?
      JC    NOEA;
      S     #OrgIndex_2_EL; //set status "single request is running"
      L     #SubsRecStartAddr; //Start addr. of subscr.-rec in BasicData
      SLD   3; //transform into pointer
      LAR1  ; //preset AR1
      L     DBW [AR1,P#8.0]; //monitoring time value [s] (BasicData)
      T     #SupvTimeEA; //preset supervision timer for single req.
NOEA: LAR1  P##OrgIndex_0_Bit_8; //Pointer on Org-Index-0 Word
      L     0;
      T     DIW [AR1,P#0.0]; //clear Org-Index-0-commands
      BEU   ;
NETWORK
TITLE =
//Enter errormessage in diagnosis-buffer.
PAFE: S     "BasicData".ParameterError; //set global Error Flag in BasicData
      A     #OrgIndex_2_PF; //parameter error is already set ?
      BEC   ; // ***** END *****
      S     #OrgIndex_2_PF;
ENTR: CALL "WR_USMSG" (//enter error message in diagnosis buffer
           SEND                     := TRUE,
           EVENTN                   := #DiagID,
           INFO1                    := #DiagInfo_1,
           INFO2                    := #DiagInfo_2,
           RET_VAL                  := #TempInt);
      BE    ;
END_FUNCTION_BLOCK

//_____________________________________________________________________________________________

FUNCTION_BLOCK "MTA02"
TITLE = 	MTA02
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : MTA02
VERSION : 1.0


VAR_INPUT
  PartnerNo : INT ;	//Subscriber-No. of communication-partner
  ST1_MessageNo : INT ;	//ST1-Message-No:	1...250;
  ST1_ObjectNo : INT ;	//ST1-Object-No:	0 or 1...250;
  ST1_IndexNo : INT ;	//ST1-Index-No:	0...255;
  Enabled : BOOL  := TRUE;	//Enable Functionblock
  ReverseDirection : BOOL ;	//reverse transm.-direction for ST1-Messages
END_VAR
VAR_OUTPUT
  OutputByte_1 : BYTE ;	//Binary-Info-Destination-Byte 1
  OutputByte_2 : BYTE ;	//Binary-Info-Destination-Byte 2
  NewData : BOOL ;	//New data received
END_VAR
VAR
  MessageLen : BYTE ;	//Msg_Header_Byte_1: Msg-Length in Bytes
  F1_Bit_0 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 0 = 0
  F1_AE_1 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 1 = AE (2 exp 0)
  F1_AE_2 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 2 = AE (2 exp 1)
  F1_FA : BOOL  := TRUE;	//Msg_Header_Byte_2: F1: Bit 3 = FA: Function Select (TIM / CPU)
  F1_Bit_4 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 4 = 0
  F1_Bit_5 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 5 = 0
  F1_Bit_6 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 6 = 0
  F1_Bit_7 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 7 = 0
  F2_Bit_0 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 0 = 0
  F2_Bit_1 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 1 = 0
  F2_Bit_2 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 2 = 0
  F2_Bit_3 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 3 = 0
  F2_X : BOOL  := TRUE;	//Msg_Header_Byte_3: F2: Bit 4 = X: Msg to be deleted on link-error
  F2_Bit_5 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 5 = 0
  F2_Bit_6 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 6 = 0
  F2_Bit_7 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 7 = 0
  F3_PR : BOOL  := TRUE;	//Msg_Header_Byte_4: F3: Bit 0: PR = 0/1 = image-mem / send-buffer
  F3_Bit_1 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 1 = 0
  F3_U : BOOL  := TRUE;	//Msg_Header_Byte_4: F3: Bit 2: U = 1: unconditional transm.
  F3_Bit_3 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 3 = 0
  F3_Bit_4 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 4 = 0
  F3_S : BOOL ;	//Msg_Header_Byte_4: F3: Bit 5: S = 1: Object is disabled
  F3_TA_1 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 6: TA (2 exp 0)
  F3_TA_2 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 7: TA (2 exp 1)
  F4_Bit_0 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 0 = 0
  F4_Bit_1 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 1 = 0
  F4_Bit_2 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 2 = 0
  F4_Bit_3 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 3 = 0
  F4_Bit_4 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 4 = 0
  F4_Bit_5 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 5 = 0
  F4_DS : BOOL ;	//Msg_Header_Byte_5: F4: Bit 6: DS = Data-transm. is disabled (not valid)
  F4_DV : BOOL ;	//Msg_Header_Byte_5: F4: Bit 7: DV = Data lost  (not valid)
  MsgHeaderByte_6 : BYTE  := B#16#12;	//Msg_Header_Byte_6: number of dest. / Len of Dest-Addr. = 2 Bytes
  DestSubscrNo : INT ;	//Destination-Subscr.-No
  ST1MsgObjNo : INT ;	//ST1-Msg-No (AE=0) / ST1-Msg-No : ST1-Obj-No (AE=1)
  SourceObjectNo : INT ;	//Source-Object-No = current Instance-DB
  StartIndexNo : INT ;	//Start-Index-No
  BinInfoByte_1_2 : WORD ;	//DATA_INDEX_0: received Binary-Info-Byte 1 and 2
  OrgIndex_0_Bit_8 : BOOL ;	//ORG_INDEX_0, Bit 8:
  OrgIndex_0_Bit_9 : BOOL ;	//ORG_INDEX_0, Bit 9:
  OrgIndex_0_Bit_10 : BOOL ;	//ORG_INDEX_0, Bit 10:
  OrgIndex_0_Bit_11 : BOOL ;	//ORG_INDEX_0, Bit 11:
  OrgIndex_0_Bit_12 : BOOL ;	//ORG_INDEX_0, Bit 12:
  OrgIndex_0_Bit_13 : BOOL ;	//ORG_INDEX_0, Bit 13:
  OrgIndex_0_Bit_14 : BOOL ;	//ORG_INDEX_0, Bit 14:
  OrgIndex_0_UEA : BOOL ;	//ORG_INDEX_0, Bit 15: param.-transm. request (not valid)
  OrgIndex_0_GA : BOOL ;	//ORG_INDEX_0, Bit 0: GA = general request (not valid)
  OrgIndex_0_EA : BOOL ;	//ORG_INDEX_0, Bit 1: EA = single request
  OrgIndex_0_Bit_2 : BOOL ;	//ORG_INDEX_0, Bit 2:
  OrgIndex_0_Bit_3 : BOOL ;	//ORG_INDEX_0, Bit 3: .
  OrgIndex_0_Bit_4 : BOOL ;	//ORG_INDEX_0, Bit 4:
  OrgIndex_0_Bit_5 : BOOL ;	//ORG_INDEX_0, Bit 5:
  OrgIndex_0_BS : BOOL ;	//ORG_INDEX_0, Bit 6: BS = disable operation (only valid if AE=0)
  OrgIndex_0_BF : BOOL ;	//ORG_INDEX_0, Bit 7: BF = enable operation (only valid if AE=0)
  OrgIndex_2_IN : BOOL ;	//ORG_INDEX_2, Bit 8: IN = Object-DB is initialized
  OrgIndex_2_FR : BOOL ;	//ORG_INDEX_2, Bit 9: FR = Object is enabled
  OrgIndex_2_Bit_10 : BOOL ;	//ORG_INDEX_2, Bit 10:
  OrgIndex_2_Bit_11 : BOOL ;	//ORG_INDEX_2, Bit 11:
  OrgIndex_2_Bit_12 : BOOL ;	//ORG_INDEX_2, Bit 12:
  OrgIndex_2_Bit_13 : BOOL ;	//ORG_INDEX_2, Bit 13:
  OrgIndex_2_Bit_14 : BOOL ;	//ORG_INDEX_2, Bit 14:
  OrgIndex_2_PF : BOOL ;	//ORG_INDEX_2, Bit 15: PF = parameter error
  OrgIndex_2_A : BOOL ;	//ORG_INDEX_2, Bit 0: A= 0/1: received data not ok/ ok
  OrgIndex_2_GL : BOOL ;	//ORG_INDEX_2, Bit 1: GA=0/1: no GenReq active/ GenReq active
  OrgIndex_2_EL : BOOL ;	//ORG_INDEX_2, Bit 2: EA=0/1: no SingleReq active/ SingleReq active
  OrgIndex_2_AF : BOOL ;	//ORG_INDEX_2, Bit 3: AF=0/1: no Req error/ Req error for last Req
  OrgIndex_2_DF : BOOL ;	//ORG_INDEX_2, Bit 4: DF=0/1: no error/error on last Data-send job (not valid)
  OrgIndex_2_OF : BOOL ;	//ORG_INDEX_2, Bit 5: OF=0/1: no error/error on last Org-send job
  OrgIndex_2_Bit_6 : BOOL ;	//ORG_INDEX_2, Bit 6:
  OrgIndex_2_Bit_7 : BOOL ;	//ORG_INDEX_2, Bit 7:
  OrgIndex_4_PR : BOOL ;	//ORG_INDEX_4, Bit 8: PR = remote Object, transm. principle
  OrgIndex_4_B : BOOL ;	//ORG_INDEX_4, Bit 9:  B = remote Object, conditional transm.
  OrgIndex_4_U : BOOL ;	//ORG_INDEX_4, Bit 10: U = remote Object, unconditional transm.
  OrgIndex_4_P : BOOL ;	//ORG_INDEX_4, Bit 11: P = remote Object, permanent transm.
  OrgIndex_4_Z : BOOL ;	//ORG_INDEX_4, Bit 12: B = remote Object, with time-stamp
  OrgIndex_4_S : BOOL ;	//ORG_INDEX_4, Bit 13: S = remote Object, Operation is disabled
  OrgIndex_4_TA_1 : BOOL ;	//ORG_INDEX_4, Bit 14: TA (2 exp 0) of last remote Object Message
  OrgIndex_4_TA_2 : BOOL ;	//ORG_INDEX_4, Bit 15: TA (2 exp 1) of last remote Object Message
  OrgIndex_4_Bit_0 : BOOL ;	//ORG_INDEX_4, Bit 0:
  OrgIndex_4_Bit_1 : BOOL ;	//ORG_INDEX_4, Bit 1:
  OrgIndex_4_Bit_2 : BOOL ;	//ORG_INDEX_4, Bit 2:
  OrgIndex_4_Bit_3 : BOOL ;	//ORG_INDEX_4, Bit 3:
  OrgIndex_4_Bit_4 : BOOL ;	//ORG_INDEX_4, Bit 4:
  OrgIndex_4_Bit_5 : BOOL ;	//ORG_INDEX_4, Bit 5:
  OrgIndex_4_Bit_6 : BOOL ;	//ORG_INDEX_4, Bit 6:
  OrgIndex_4_Bit_7 : BOOL ;	//ORG_INDEX_4, Bit 7:
  RecTimeStamp_1 : DWORD ;	//Time_Stamp: Year, Month, Day, Hour
  RecTimeStamp_2 : DWORD ;	//Time_Stamp: Minute, Second, MSec*10, MSec*1/Status
  IntNewSendReq_Cmd : BOOL ;	//New Send-Request for Commands
  IntNewSendReq_Param : BOOL ;	//New Send-Request for Parameters (not valid)
  IntNewSendReq_Org0 : BOOL ;	//New Send-Request for OrgIndex_0
  IntNewSendReq_spare : BOOL ;	//Spare
  IntNewSendReq_spare_1 : BOOL ;	//Spare
  IntNewSendReq_spare_2 : BOOL ;	//Spare
  IntNewSendReq_spare_3 : BOOL ;	//Spare
  IntNewSendReq_spare_4 : BOOL ;	//Spare
  IntOldSendReq_Cmd : BOOL ;	//Old Send-Request for Commands
  IntOldSendReq_Param : BOOL ;	//Old Send-Request for Parameters (not valid)
  IntOldSendReq_Org0 : BOOL ;	//Old Send-Request for OrgIndex_0
  IntOldSendReq_spare : BOOL ;	//Spare
  IntOldSendReq_spare_1 : BOOL ;	//Spare
  IntOldSendReq_spare_2 : BOOL ;	//Spare
  IntOldSendReq_spare_3 : BOOL ;	//Spare
  IntOldSendReq_spare_4 : BOOL ;	//Spare
  SupvTimeEA : INT ;	//supervisison timer (s) for Single Request
  SubsRecStartAddr : WORD ;	//Start-address of data-record in subscriber-database
  MaxNumbOfPartners : BYTE  := B#16#1;	//SEND_POINTER: max. number of partners
  ParamNumbOfPartners : BYTE  := B#16#1;	//SEND_POINTER: parametr. number of partners
  SendMsgStartAddr : WORD ;	//SEND_POINTER: Start-address of send-message
  NumbOfBytesToSend : BYTE  := B#16#2;	//SEND_POINTER: number of bytes to send, starting with Start Index No
  LinkErrorFlags : BYTE ;	//SEND_POINTER: Link error flags to partner
  SendReqFlags : BYTE ;	//SEND_POINTER: Send-request-flags to Partner
  DataLostFlags : BYTE ;	//SEND_POINTER: Flags to indicate lost messages to partner
  AddrDataIndex_0 : WORD ;	//BASE_POINTER: Address of DATA-INDEX-0
  AddrOrgIndex_0 : WORD ;	//BASE_POINTER: Address of ORG-INDEX-0
  NumbOfRecvdBytes : BYTE ;	//BASE_POINTER: number of received Bytes in last recv. message
  MaxRecvDataBytes : BYTE  := B#16#2;	//BASE_POINTER: number of max. possible recv. data-bytes
  ST7_ID : BYTE  := B#16#A5;	//BASE_POINTER: SINAUT ST7 Object-DB-ID = A5
  LastByte_SZ : BOOL  := TRUE;	//BASE_POINTER: Last-Byte: SZ = 1: send-pointers available
  LastByte_EA : BOOL ;	//BASE_POINTER: Last-Byte: EA = 1: space for receive addresses (not valid)
  LastByte_EZ : BOOL  := TRUE;	//BASE_POINTER: Last-Byte: EZ = 1: space for receive time stamp
  LastByte_Bit_3 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 3:
  LastByte_Bit_4 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 4:
  LastByte_Bit_5 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 5:
  LastByte_Bit_6 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 6:
  LastByte_Bit_7 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 7:
END_VAR
VAR_TEMP
  SearchPartner : DWORD ;
  SearchRetVal : DWORD ;
  DiagID : WORD ;
  DiagInfo_1 : WORD ;
  DiagInfo_2 : DWORD ;
  DBObjRefList : WORD ;
  PointRcvOrgIndex : DWORD ;
  PointSendOrgIndex : DWORD ;
  TempInt : INT ;
  Save_AR1 : DWORD ;
  Save_AR2 : DWORD ;
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!

RUN:  NOP   0;

NETWORK
TITLE =
//Create Object Reference List ?
      AN    "BasicData".ObjRefListLen; //prepare ref-list-generation
      JC    M000;
      L     "BasicData".NofObjectItems1; //old number of objects in ref-list
      +     1;
      T     "BasicData".NofObjectItems1; //new number of objects in ref-list

NETWORK
TITLE =
//Typical-Initialisation and basic settings.
M000: LAR1  P##OrgIndex_0_Bit_8; //set pointer on ORG_INDEX_0 Word
      A     #OrgIndex_2_IN; //Object-DB is initialized ?
      JC    STRT;
      S     "BasicData".ObjRefListGen; //request for list generation
      A     #Enabled; //Typical is enabled ?
      S     #OrgIndex_2_FR; //set statusbit "Object is enabled"
      JC    PSET;
      S     #F3_S; //set "Object disabled" in Msg-header
      JU    PSET;
STRT: A     "BasicData".SystemStart; //System-Startup ?
      R     #OrgIndex_2_PF; //reset No error ?
      AN    "BasicData".SystemStart; //System-Startup ?
      AN    #OrgIndex_2_PF; //no No error ?
      JC    M002;
      L     DIW [AR1,P#2.0]; //ORG_INDEX_2 in Akku 1
      L     2#1000001100000000; //mask on PF,..., FR, IN
      AW    ;
      T     DIW [AR1,P#2.0]; //store ORG_INDEX_2
PSET: L     P##MessageLen; //Pointer on first message byte
      SRW   3; //transform into Integervalue
      T     #SendMsgStartAddr; //preset Object-DB
      L     P##BinInfoByte_1_2; //Pointer on Data Index 0
      SRW   3; //transform into Integervalue
      T     #AddrDataIndex_0; //preset Object-DB
      L     P##OrgIndex_0_Bit_8; //set pointer on ORG_INDEX_0
      SRW   3; //transform into Integervalue
      T     #AddrOrgIndex_0; //preset Object-DB
      AN    #OrgIndex_2_IN;
      S     #OrgIndex_2_IN; //set statusbit "Object is initialized"
      LAR1  P##F4_Bit_0; //set pointer on F4-Array
      L     0;
      T     DIB [AR1,P#0.0]; //preset F4-Array with 0

NETWORK
TITLE =
//Preset Object-DB if system startup.
      L     0;
      L     #PartnerNo; //Destination
      >=I   ;
      JC    ERR1; //Error 1: Partner No or Obj.-No not correct
      SLD   16;
      T     #SearchPartner; //preset data for FC_SEARCH
      TAR1  #Save_AR1; //save AR1
      TAR2  #Save_AR2; //save AR2

      CALL "Search" (
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #SearchPartner,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #SearchRetVal);

      LAR1  #Save_AR1; //restore AR1
      LAR2  #Save_AR2; //restore AR2
      L     0;
      L     #SearchRetVal; //result of "SEARCH"
      <=D   ;
      JC    ADOK; //no error in "SEARCH", address = ok
      L     W#16#B101; //Error-ID: PartnerNo not found in Subscr. List
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //unknown Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ERR1: L     W#16#B100; //Error-ID: PartnerNo not valid
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //incorrect Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ADOK: T     #SubsRecStartAddr; //start-addr. in subscr. database
      R     #OrgIndex_2_PF; //reset No error
      S     "BasicData".ObjRefListGen; //request for list generation
      L     #PartnerNo; //Input: Destination-partner-No
      T     #DestSubscrNo; //dest.-Partner-No in Msg
      L     1;
      T     #ParamNumbOfPartners; //param.  No of Partners
      L     0; //
      T     #SendReqFlags; //clear send-req-mask
      T     #DataLostFlags; //clear data-lost-mask
      T     #LinkErrorFlags; //clear link-error-mask
      T     #NumbOfRecvdBytes; //delete number of recvd bytes
      LAR1  P##OrgIndex_0_Bit_8; //Pointer on Org-Index 0
      T     DIW [AR1,P#0.0]; //delete ORG_INDEX_0 flags
      LAR1  P##IntNewSendReq_Cmd; //Pointer on internal Send-flags
      T     DIW [AR1,P#0.0]; //delete internal NEW_ and OLD_SendReq-flags

NETWORK
TITLE =
//Preset ST1-Parameters.
      L     0;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >=I   ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     250; //max. value for ST1_Message_No
      >I    ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      L     0;
      <I    ;
      JC    EROB; //Error in Object No.
      >I    ;
      JC    AE1; //ST1-Message with AE = 1
      L     2;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >I    ; //Message_No < 2 and Obj.-No < 1 ?
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      R     #F1_AE_1; //enter AE_ID = 0 into F1-Field
      R     #F1_AE_2; //    "          "          "
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE0R;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #ST1MsgObjNo; //preset Message
      L     DINO; //local Object No
      T     #SourceObjectNo; //preset message
      JU    M002;
AE0R: L     0;
      T     #ST1MsgObjNo; //preset message;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #SourceObjectNo; //preset message
      JU    M002;
AE1:  S     #F1_AE_1; //enter AE_ID = 1 into F1-Field
      R     #F1_AE_2; //    "          "          "
      L     255;
      L     #ST1_IndexNo; //Input Parameter
      <I    ;
      JC    ERIN;
      L     0;
      <I    ;
      JC    ERIN; //Error : Index_No < 0
      POP   ;
      SLW   1; //multiply with 2
      L     #AddrDataIndex_0; //Start-Addr. Data-Index 0
      TAK   ;
      -I    ;
      T     #AddrDataIndex_0; //preset base-pointer
      L     255;
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      <I    ;
      JC    EROB;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      SLW   8; //Shift Message_No into High_Byte
      OW    ;
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE1R;
      T     #ST1MsgObjNo; //enter into message-area
      L     DINO; //local Object No
      T     #SourceObjectNo; //enter into message-area
      JU    M002;
AE1R: T     #SourceObjectNo; //preset message
      L     0;
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
ER10: L     W#16#B103; //Error-ID: ST1_Message_No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_MessageNo; //incorrect ST1-Message-No
      T     #DiagInfo_2;
      JU    PAFE;
EROB: L     W#16#B104; //Error-ID: Object-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_ObjectNo; //incorrect ST1-Object-No
      T     #DiagInfo_2;
      JU    PAFE;
ERIN: L     W#16#B105; //Error-ID: Index-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_IndexNo; //incorrect ST1-Index-No
      T     #DiagInfo_2;
      JU    PAFE;

NETWORK
TITLE =
//Entry in Object Reference List required ?
M002: AN    "BasicData".ObjRefListEntry; //enter item in ref-list ?
      JC    NXNW;
      L     "BasicData".DB_ObjectList1; //DB-No. Subscriber List 1
      T     #DBObjRefList; //store temporarily
      OPN   DB [#DBObjRefList]; //open DB ObjRefList1
      L     DBW    0; //address of next free block
      SLD   3; //convert INT into pointer
      LAR1  ; //preset address-reg. 1
      L     #PartnerNo; //No. of comm.-partner
      AN    #ReverseDirection; //no operation in rev. Dir. ?
      JC    NORM;
      L     "BasicData".OwnSubscrNo; //local Subscriber No
      OPN   DB [#DBObjRefList]; //open DB ObjRefList1
NORM: T     DBW [AR1,P#0.0]; //store in Ref.List
      L     #ST1MsgObjNo; //local input parameter
      AN    #ReverseDirection; //no reverse transmission mode ?
      JC    STOR;
      L     #SourceObjectNo; //
STOR: T     DBW [AR1,P#2.0]; //store in Ref.List
      L     DINO; //local object No
      T     DBW [AR1,P#4.0]; //store in Ref.List
      L     DBW    0; //old address of next free block
      +     6; //add offset on next free block
      T     DBW    0; //new address of next free block

NETWORK
TITLE =
//Enable / disable Typical-Operation ?
NXNW: AN    #Enabled; //Object is not enabled ?
      JC    DISA;
      AN    #OrgIndex_2_FR; //statusflag "enabled" is not set ?
      S     #OrgIndex_2_FR; //set statusflag
      S     #OrgIndex_0_EA; //set single req. command
      R     #F3_S; //reset flag in Msg-header
      JU    CYCL;
DISA: R     #OrgIndex_2_FR; //reset statusflag
      S     #F3_S; //set flag in Msg-header

NETWORK
TITLE =
//Process GA-Start-Bit
CYCL: L     #SubsRecStartAddr; //address of Subscr. Record in BasicData
      L     "BasicData".OffsetSendOrgIndex0; //offset on Send-Index in Subscr.-Rec.
      +D    ;
      SLD   3; //transform into pointer
      T     #PointSendOrgIndex; //store Pointer temporarily
      L     #SubsRecStartAddr; //address of Subscr. Record in BasicData
      L     "BasicData".OffsetRcvOrgIndex0; //offset on Receive-Index in Subscr.-Rec.
      +D    ;
      SLD   3; //transform into pointer
      T     #PointRcvOrgIndex; //store Pointer temporarily
      LAR1  ; //load AR1 with address of Recv.-Index 0
      A     DBX [AR1,P#3.1]; //GA-Start-Bit in Recv.-Index 2 is set ?
      S     #OrgIndex_2_GL; //set status "GenReq is active"
NETWORK
TITLE =
//Basic processing of received message
      L     #NumbOfRecvdBytes; //********************************
      L     0; //number of received bytes = 0 ? =>
      ==I   ; //   no new message received
      R     #NewData; //
      JC    SUPV; //
      S     #NewData; //
      T     #NumbOfRecvdBytes; //********************************
      A     #OrgIndex_4_TA_2; //TA = 2: received message =
      AN    #OrgIndex_4_TA_1; //        normal data message ?
      JC    RESA; //********************************
      AN    #OrgIndex_4_S; //remote Object is not disabled ?
      AN    #OrgIndex_2_GL; //no GenReq is active ?
      AN    #OrgIndex_2_EL; //no SingleReq is active ?
      S     #OrgIndex_2_A; //set status "received data valid"
      O     #OrgIndex_2_GL; //GenReq is active ?
      O     #OrgIndex_2_EL; //SingleReq is active ?
      R     #OrgIndex_2_GL; //reset GenReq status-bit
      R     #OrgIndex_2_EL; //reset SingleReq status-bit
      R     #OrgIndex_2_AF; //reset Request-error status-bit
      S     #OrgIndex_2_A; //set status "received data valid"
RESA: ON    #OrgIndex_2_FR; //local Object is not enabled ?
      O     #OrgIndex_4_S; //remote Object is disabled ?
      R     #OrgIndex_2_A; //reset status "received data valid"

NETWORK
TITLE =
//General-/Single-request supervision.
SUPV: AN    DBX [AR1,P#5.0]; //Status "Partner is not o.k." (BasicData) ?
      R     #OrgIndex_2_A; //reset status "data valid"
      AN    #OrgIndex_2_GL; //GenReq is not active ?
      JC    SREQ;
      LAR1  #PointSendOrgIndex; //set AR1 on Send-Index 0 in BasicData
      S     DBX [AR1,P#5.3]; //set "GenReq incomplete" in Subscr.-Rec.
      LAR1  #PointRcvOrgIndex; //set AR1 on Receive-Index 0 in BasicData
      AN    DBX [AR1,P#3.2]; //GA-End-Bit in Recv.-Index 2 is not set ?
      JC    SREQ;
      R     #OrgIndex_2_GL; //reset GenReq status-bit
      S     #OrgIndex_2_AF; //set Request-error status-bit
      R     #OrgIndex_2_A; //reset status "received data valid"
      L     W#16#B162; //Error-ID: GA not correctly terminated
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //Dest.-Subscriber-No
      T     #DiagInfo_2;
      JU    ENTR;
SREQ: ON    #OrgIndex_2_EL; //SingleReq is not active ?
      ON    "BasicData".Pulse_1s; //1-s-Pulse is not active ?
      JC    OUTP;
      L     #SupvTimeEA; //Single request supervision timer, old
      +     -1; //decrement timer
      T     #SupvTimeEA; //Single request supervision timer, new
      L     0;
      >I    ;
      JC    OUTP; //Single Request still running, timer > 0
      R     #OrgIndex_2_EL; //reset Status "single request running"
      R     #OrgIndex_2_A; //reset Status "received data valid"
      S     #OrgIndex_2_AF; //set Status "request error"
      L     W#16#B163; //Error-ID: EA not correctly terminated
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //Dest.-Subscriber-No
      T     #DiagInfo_2;
      JU    ENTR;

NETWORK
TITLE =
//Write received Binary-Info-bytes to output-addresses.
OUTP: ON    #OrgIndex_2_FR; //Typical is not enabled ?
      ON    #NewData; //no new data received ?
      JC    ORG0;
      LAR1  P##BinInfoByte_1_2; //Pointer on received binary info bytes
      L     DIW [AR1,P#0.0]; //receiced binary info, 16 Bit
      LAR1  P##OutputByte_1; //Pointer on Output-addresses
      T     DIW [AR1,P#0.0]; //write 16 Bit binary info to outputs

NETWORK
TITLE =
//Start and monitor Org Index 0 transmission.
ORG0: LAR1  P##OrgIndex_0_Bit_8; //Pointer on Org-Index-0 Word
      O     #F1_AE_1; //AE is not 0 ?
      O     #F1_AE_2; //AE is not 0 ?
      R     #OrgIndex_0_BF; //reset Org-Command "enable operation" ?
      R     #OrgIndex_0_BS; //reset Org-Command "disable operation" ?
      A     #OrgIndex_0_BF; //Org-Command "enable operation" ?
      S     #OrgIndex_0_EA; //Org-Command "single request command"
      L     DIW [AR1,P#0.0]; //Index_0 into Akku 1
      L     2#11000010; //mask on BF,BS and EA
      AW    ;
      T     DIW [AR1,P#0.0]; //restore Index_0
      L     0;
      ==I   ; //no new Job in Org_Index_0 ?
      AN    #IntNewSendReq_Org0; //************************************
      BEC   ; //
      S     #IntNewSendReq_Org0; //set internal flag "Send-Job started"
      L     1; //* PRESET SEND_AREA IN OBJECT_DB !  *
      T     #SendReqFlags; //* set send-flag 0 for FC_CREATE    *
      TAR2  #Save_AR2; //save AR2

      CALL "Create" (
           SubscriberObject         := FALSE);

      LAR2  #Save_AR2; //restore AR2
      LAR1  P##SendReqFlags; //set pointer on send-request flags
      A     DIX [AR1,P#0.0]; //SendReqFlag is still set ?
      BEC   ;
      R     #IntNewSendReq_Org0; //reset internal flag "Send-Job started"
      A     #OrgIndex_0_EA; //single request command ?
      A     #OrgIndex_2_OF; //error on Org Index transmission ?
      S     #OrgIndex_2_AF; //set status "error on last request answer"
      R     #OrgIndex_2_A; //reset status "received data valid"
      ON    #OrgIndex_0_EA; //no single request command ?
      O     #OrgIndex_2_OF; //error on Org Index transmission ?
      JC    NOEA;
      S     #OrgIndex_2_EL; //set status "single request is running"
      L     #SubsRecStartAddr; //Start addr. of subscr.-rec in BasicData
      SLD   3; //transform into pointer
      LAR1  ; //preset AR1
      L     DBW [AR1,P#8.0]; //monitoring time value [s] (BasicData)
      T     #SupvTimeEA; //preset supervision timer for single req.
NOEA: LAR1  P##OrgIndex_0_Bit_8; //Pointer on Org-Index-0 Word
      L     0;
      T     DIW [AR1,P#0.0]; //clear Org-Index-0-commands
      BEU   ;

NETWORK
TITLE =
//Enter errormessage in diagnosis-buffer.
PAFE: S     "BasicData".ParameterError; //set global Error Flag in BasicData
      A     #OrgIndex_2_PF; //parameter error is already set ?
      BEC   ; // ***** END *****
      S     #OrgIndex_2_PF;

ENTR: CALL "WR_USMSG" (
           SEND                     := TRUE,//enter error message in diagnosis buffer
           EVENTN                   := #DiagID,
           INFO1                    := #DiagInfo_1,
           INFO2                    := #DiagInfo_2,
           RET_VAL                  := #TempInt);

END_FUNCTION_BLOCK

//_____________________________________________________________________________________________

FUNCTION_BLOCK "ATZ01"
TITLE = ATZ01
AUTHOR : SINAUT_7
FAMILY : Basic01
NAME : ATZ01
VERSION : 1.1


VAR_INPUT
  PartnerNo : INT ;	//Subscriber-No. of communication-partner
  ST1_MessageNo : INT ;	//ST1-Message-No:	1...250;
  ST1_ObjectNo : INT ;	//ST1-Object-No:	0 or 1...250;
  ST1_IndexNo : INT ;	//ST1-Index-No:	0...255;
  ST1_PACK_Value : INT ;	//ST1-PACK-Value:	0, 1, 2 or 4;
  Enabled : BOOL  := TRUE;	//Enable Functionblock
  ImageMemory : BOOL  := TRUE;	//image-memory-message
  Conditional : BOOL  := TRUE;	//conditional spontanous transm.
  Unconditional : BOOL ;	//unconditional spontanous transm.
  Permanent : BOOL ;	//permanent transm.
  TimeStamp : BOOL ;	//Message with time-stamp ?
  ThresholdIntegration : BOOL ;	//Process threshold integration of Analogvalue
  ZeroLimitation : BOOL  := TRUE;	//Min. value limitation to zero
  TriggerInput : BOOL ;	//Trigger Input for message-send-initiation
  ReverseDirection : BOOL ;	//reverse transm.-direction for ST1-Messages
  LifeZero : BOOL ;	//Life Zero Analog Input
  AnalogInput_1 : WORD ;	//Analog-Input-Value 1
  AnalogInput_2 : WORD ;	//Analog-Input-Value 2
  AnalogInput_3 : WORD ;	//Analog-Input-Value 3
  AnalogInput_4 : WORD ;	//Analog-Input-Value 4
  SamplingPeriod : INT  := 500;	//Sampling period for analog inputs
  ThresholdValue : INT  := 270;	//Threshold value; 270 <=> 1% of range
  SmoothingFactor : INT  := 1;	//smoothing factor: 1 = none; 4, 32, 64=max.
  FaultSuppressionTime : INT ;	//suppress transmission in case of overflow
END_VAR
VAR
  MessageLen : BYTE ;	//Msg_Header_Byte_1: Msg-Length in Bytes
  F1_Bit_0 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 0 = 0
  F1_AE_1 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 1 = AE (2 exp 0)
  F1_AE_2 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 2 = AE (2 exp 1)
  F1_FA : BOOL  := TRUE;	//Msg_Header_Byte_2: F1: Bit 3 = FA: Function Select (TIM / CPU)
  F1_Bit_4 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 4 = 0
  F1_Bit_5 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 5 = 0
  F1_Bit_6 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 6 = 0
  F1_Bit_7 : BOOL ;	//Msg_Header_Byte_2: F1: Bit 7 = 0
  F2_Bit_0 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 0 = 0
  F2_PACK_1 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 1 = PACK 2exp0
  F2_PACK_2 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 2 = PACK 2exp1
  F2_PACK_3 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 3 = PACK 2exp2
  F2_Bit_4 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 4 = 0
  F2_Bit_5 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 5 = 0
  F2_Bit_6 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 6 = 0
  F2_Bit_7 : BOOL ;	//Msg_Header_Byte_3: F2: Bit 7 = 0
  F3_PR : BOOL ;	//Msg_Header_Byte_4: F3: Bit 0: PR = 0/1 = image-mem / send-buffer
  F3_B : BOOL ;	//Msg_Header_Byte_4: F3: Bit 1: B = 1: conditional transm.
  F3_U : BOOL ;	//Msg_Header_Byte_4: F3: Bit 2: U = 1: unconditional transm.
  F3_P : BOOL ;	//Msg_Header_Byte_4: F3: Bit 3: P = 1: permanent transm.
  F3_Z : BOOL ;	//Msg_Header_Byte_4: F3: Bit 4: Z = 1: with time-stamp
  F3_S : BOOL ;	//Msg_Header_Byte_4: F3: Bit 5: S = 1: Object is disabled
  F3_TA_1 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 6: TA (2 exp 0)
  F3_TA_2 : BOOL ;	//Msg_Header_Byte_4: F3: Bit 7: TA (2 exp 1)
  F4_Bit_0 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 0 = 0
  F4_Bit_1 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 1 = 0
  F4_Bit_2 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 2 = 0
  F4_Bit_3 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 3 = 0
  F4_Bit_4 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 4 = 0
  F4_Bit_5 : BOOL ;	//Msg_Header_Byte_5: F4: Bit 5 = 0
  F4_DS : BOOL ;	//Msg_Header_Byte_5: F4: Bit 6: DS = Data-transm. is disabled (not valid)
  F4_DV : BOOL ;	//Msg_Header_Byte_5: F4: Bit 7: DV = Data lost
  MsgHeaderByte_6 : BYTE  := B#16#2;	//Msg_Header_Byte_6: number. of dest. / Len of Dest-Addr. = 2 Bytes
  DestSubscrNo : INT ;	//Destination-Subscr.-No
  DestObjectNo : INT ;	//Destination-Object-No
  ST1MsgObjNo : INT ;	//ST1-message-no. /message- and object-no.
  StartIndexNo : INT ;	//Start-Index-No
  Time_Stamp_1 : DWORD ;	//Time_Stamp: Year, Month, Day, Hour
  Time_Stamp_2 : DWORD ;	//Time_Stamp: Minute, Second, MSec*10, MSec*1/Status
  AnalogValue_1 : WORD ;	//DATA_INDEX_0: Analog Value 1
  AnalogValue_2 : WORD ;	//DATA_INDEX_2: Analog Value 2
  AnalogValue_3 : WORD ;	//DATA_INDEX_4: Analog Value 3
  AnalogValue_4 : WORD ;	//DATA_INDEX_6: Analog Value 4
  OrgIndex_0_Bit_8 : BOOL ;	//ORG_INDEX_0, Bit 8:
  OrgIndex_0_Bit_9 : BOOL ;	//ORG_INDEX_0, Bit 9:
  OrgIndex_0_Bit_10 : BOOL ;	//ORG_INDEX_0, Bit 10:
  OrgIndex_0_Bit_11 : BOOL ;	//ORG_INDEX_0, Bit 11:
  OrgIndex_0_Bit_12 : BOOL ;	//ORG_INDEX_0, Bit 12:
  OrgIndex_0_Bit_13 : BOOL ;	//ORG_INDEX_0, Bit 13:
  OrgIndex_0_Bit_14 : BOOL ;	//ORG_INDEX_0, Bit 14:
  OrgIndex_0_UEA : BOOL ;	//ORG_INDEX_0, Bit 15: param.-transm. request (not valid)
  OrgIndex_0_GA : BOOL ;	//ORG_INDEX_0, Bit 0: GA = general request
  OrgIndex_0_EA : BOOL ;	//ORG_INDEX_0, Bit 1: EA = single request
  OrgIndex_0_DS : BOOL ;	//ORG_INDEX_0, Bit 2: DS = disable data transmission (not valid)
  OrgIndex_0_DF : BOOL ;	//ORG_INDEX_0, Bit 3: DF = enable data transmission (not valid)
  OrgIndex_0_Bit_4 : BOOL ;	//ORG_INDEX_0, Bit 4:
  OrgIndex_0_Bit_5 : BOOL ;	//ORG_INDEX_0, Bit 5:
  OrgIndex_0_BS : BOOL ;	//ORG_INDEX_0, Bit 6:  BS =disable operation (only if AE = 0)
  OrgIndex_0_BF : BOOL ;	//ORG_INDEX_0, Bit 7:  BF = enable operation (only if AE = 0)
  OrgIndex_2_IN : BOOL ;	//ORG_INDEX_2, Bit 8:  IN = Object-DB is initialized
  OrgIndex_2_FR : BOOL ;	//ORG_INDEX_2, Bit 9:  FR = Object is enabled
  OrgIndex_2_SP : BOOL ;	//ORG_INDEX_2, Bit 10: SP = Object was disabled by ORG_0_command "BS"
  OrgIndex_2_EUE : BOOL ;	//ORG_INDEX_2, Bit 11: EUE= First transm. after start done
  OrgIndex_2_ZB : BOOL ;	//ORG_INDEX_2, Bit 12: ZB = Msg sent after status "Time ok"
  OrgIndex_2_Bit_13 : BOOL ;	//ORG_INDEX_2, Bit 13:
  OrgIndex_2_Bit_14 : BOOL ;	//ORG_INDEX_2, Bit 14:
  OrgIndex_2_PF : BOOL ;	//ORG_INDEX_2, Bit 15: PF = parameter error
  OrgIndex_2_Bit_0 : BOOL ;	//ORG_INDEX_2, Bit 0:
  OrgIndex_2_Bit_1 : BOOL ;	//ORG_INDEX_2, Bit 1:
  OrgIndex_2_Bit_2 : BOOL ;	//ORG_INDEX_2, Bit 2:
  OrgIndex_2_Bit_3 : BOOL ;	//ORG_INDEX_2, Bit 3:
  OrgIndex_2_Bit_4 : BOOL ;	//ORG_INDEX_2, Bit 4:
  OrgIndex_2_Bit_5 : BOOL ;	//ORG_INDEX_2, Bit 5:
  OrgIndex_2_Bit_6 : BOOL ;	//ORG_INDEX_2, Bit 6:
  OrgIndex_2_Bit_7 : BOOL ;	//ORG_INDEX_2, Bit 7:
  OrgIndex_4_PR : BOOL ;	//ORG_INDEX_4, Bit 8: PR = remote Object, transm. principle
  OrgIndex_4_Bit_9 : BOOL ;	//ORG_INDEX_4, Bit 9:
  OrgIndex_4_U : BOOL ;	//ORG_INDEX_4, Bit 10: U = remote Object, unconditional transm.
  OrgIndex_4_Bit_11 : BOOL ;	//ORG_INDEX_4, Bit 11:
  OrgIndex_4_Bit_12 : BOOL ;	//ORG_INDEX_4, Bit 12:
  OrgIndex_4_Bit_13 : BOOL ;	//ORG_INDEX_4, Bit 13:
  OrgIndex_4_TA_1 : BOOL ;	//ORG_INDEX_4, Bit 14: TA (2 exp 0) of last remote Object message
  OrgIndex_4_TA_2 : BOOL ;	//ORG_INDEX_4, Bit 15: TA (2 exp 1) of last remote Object message
  OrgIndex_4_Bit_0 : BOOL ;	//ORG_INDEX_4, Bit 0:
  OrgIndex_4_Bit_1 : BOOL ;	//ORG_INDEX_4, Bit 1:
  OrgIndex_4_Bit_2 : BOOL ;	//ORG_INDEX_4, Bit 2:
  OrgIndex_4_Bit_3 : BOOL ;	//ORG_INDEX_4, Bit 3:
  OrgIndex_4_Bit_4 : BOOL ;	//ORG_INDEX_4, Bit 4:
  OrgIndex_4_Bit_5 : BOOL ;	//ORG_INDEX_4, Bit 5:
  OrgIndex_4_Bit_6 : BOOL ;	//ORG_INDEX_4, Bit 6:
  OrgIndex_4_Bit_7 : BOOL ;	//ORG_INDEX_4, Bit 7:
  IntNewSendReq_Data : BOOL ;	//New Send Request for Process-Data
  IntNewSendReq_Param : BOOL ;	//New Send Request for Parameters (not valid)
  IntNewSendReq_GA : BOOL ;	//New Send Request for General Request (GA)
  IntNewSendReq_EA : BOOL ;	//New Send Request for Single Request (EA)
  IntNewSendReq_spare_1 : BOOL ;	//Spare
  IntNewSendReq_spare_2 : BOOL ;	//Spare
  IntNewSendReq_spare_3 : BOOL ;	//Spare
  IntNewSendReq_spare_4 : BOOL ;	//Spare
  IntOldSendReq_Data : BOOL ;	//Old Send Request for Process-Data
  IntOldSendReq_Param : BOOL ;	//Old Send Request for Parameters (not valid)
  IntOldSendReq_GA : BOOL ;	//Old Send Request for General Request (GA)
  IntOldSendReq_EA : BOOL ;	//Old Send Request for Single Request (EA)
  IntOldSendReq_spare_1 : BOOL ;	//Spare
  IntOldSendReq_spare_2 : BOOL ;	//Spare
  IntOldSendReq_spare_3 : BOOL ;	//Spare
  IntOldSendReq_spare_4 : BOOL ;	//*****************************************************************
  AV1Smooth : INT ;	//Analog value 1, smoothened
  AV1IntSum : INT ;	//Analog value 1, integrated sum-value
  AV1FaultSupTimer : INT ;	//Analog value 1, fault suppression timer (s)
  AV1Status : WORD ;	//Analog value 1, Status *******************
  AV2Smooth : INT ;	//Analog value 2, smoothened
  AV2IntSum : INT ;	//Analog value 2, integrated sum-value
  AV2FaultSupTimer : INT ;	//Analog value 2, fault suppression timer (s)
  AV2Status : WORD ;	//Analog value 2, Status *******************
  AV3Smooth : INT ;	//Analog value 3, smoothened
  AV3IntSum : INT ;	//Analog value 3, integrated sum-value
  AV3FaultSupTimer : INT ;	//Analog value 3, fault suppression timer (s)
  AV3Status : WORD ;	//Analog value 3, Status *******************
  AV4Smooth : INT ;	//Analog value 4, smoothened
  AV4IntSum : INT ;	//Analog value 4, integrated sum-value
  AV4FaultSupTimer : INT ;	//Analog value 4, fault suppression timer (s)
  AV4Status : WORD ;	//Analog value 4, Status *******************
  OldAV1_S7 : WORD ;	//last sent value 1 in S7-Format
  OldAV2_S7 : WORD ;	//last sent value 2 in S7-Format
  OldAV3_S7 : WORD ;	//last sent value 3 in S7-Format
  OldAV4_S7 : WORD ;	//last sent value 4 in S7-Format
  SamplingPeriodTimer : INT ;	//sampling period timer (ms)
  TriggerPosEdgeFlag : BOOL ;	//pos. edge flag for TriggerInput
  ExternalSendReq : BOOL ;	//external send request by TriggerInput
  InternalSendReq : BOOL ;	//internal send request by limit-exceeding
  Online_FR : BOOL ;
  ThresholdValueZero : BOOL ;	//ThresholdValue = 0 : no threshold processing
  IntSpareBit5 : BOOL ;	//Spare
  IntSpareBit6 : BOOL ;	//Spare
  IntSpareBit7 : BOOL ;	//Spare
  NoOfST1_Objects : BYTE ;	//******** END OF INTERNAL STAT_VARS ********
  SubsRecStartAddr : WORD ;	//Start-address of data-record in subscriber-database
  MaxNumbOfPartners : BYTE  := B#16#1;	//SEND_POINTER: max. number of partners
  ParamNumbOfPartners : BYTE ;	//SEND_POINTER: parametr. number of partners
  SendMsgStartAddr : WORD ;	//SEND_POINTER: Start-address of send-message
  NumbOfBytesToSend : BYTE ;	//SEND_POINTER: number of bytes to send, starting with Start Index No
  LinkErrorFlags : BYTE ;	//SEND_POINTER: Link Error flags to partner 1 (...8)
  SendReqFlags : BYTE ;	//SEND_POINTER: Send-request-flags to Partner 1 (...8)
  DataLostFlags : BYTE ;	//SEND_POINTER: Flags to indicate lost messages to partner 1 (...8)
  AddrDataIndex_0 : WORD ;	//BASE_POINTER: Address of DATA-INDEX-0
  AddrOrgIndex_0 : WORD ;	//BASE_POINTER: Address of ORG-INDEX-0
  NumbOfRecvdBytes : BYTE ;	//BASE_POINTER: number of received Bytes in last recv. message
  MaxRecvDataBytes : BYTE ;	//BASE_POINTER: number of max. possible recv. data-bytes
  ST7_ID : BYTE  := B#16#A5;	//BASE_POINTER: SINAUT ST7 Object-DB-ID = A5
  LastByte_SZ : BOOL  := TRUE;	//BASE_POINTER: Last-Byte: SZ = 1: send-pointers available
  LastByte_EA : BOOL ;	//BASE_POINTER: Last-Byte: EA = 1: space for receive addresses (not valid)
  LastByte_EZ : BOOL ;	//BASE_POINTER: Last-Byte: SZ = 1: space for received time stamp (not valid)
  LastByte_Bit_3 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 3:
  LastByte_Bit_4 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 4:
  LastByte_Bit_5 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 5:
  LastByte_Bit_6 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 6:
  LastByte_Bit_7 : BOOL ;	//BASE_POINTER: Last-Byte: Bit 7:
END_VAR
VAR_TEMP
  SearchPartner : DWORD ;
  SearchRetVal : DWORD ;
  DiagID : WORD ;
  DiagInfo_1 : WORD ;
  DiagInfo_2 : DWORD ;
  DBObjRefList : WORD ;
  TempInt : INT ;
  ActValue : INT ;
  LastSentData : INT ;
  AV_Delta : INT ;
  SendReqFlag_0 : BOOL ;
  ReleaseOperation : BOOL ;
  Save_AR1 : DWORD ;
  Save_AR2 : DWORD ;
END_VAR
BEGIN
NETWORK
TITLE =
//Check SINAUT keyword !
      OPN   "BasicData"; //Open DB BasicData
      L     DBLG; //length of DB BasicData
      +     -4;
      SLD   3; //transform into pointer-format
      LAR1  ; //preset AR1
      L     DBD [AR1,P#0.0]; //load last DBD of BasicData
      L     'ST 7'; //keyword = 'ST 7' ?
      ==D   ;
      JC    RUN;
      CALL "STP" ;//Stop CPU !!!
RUN:  NOP   0;
NETWORK
TITLE =
//Create Object Reference List 2 ?
      ON    "BasicData".ObjRefListLen; //prepare ref-list-generation
      O     #ReverseDirection; //reverse transmission mode ?
      JC    M000;
      AN    #F1_AE_1; //no AE=1-Telegramme ?
      JC    OBJ1;
      L     0; //default = 1 Object
      L     #ST1_PACK_Value; //Input Parameter
      ==I   ;
      JC    OBJ1;
      L     4; //1 Object = 4 Analog-Values
      ==I   ;
      JC    OBJ1;
      POP   ;
      L     1; //1 Object = 1 Analog-Value
      ==I   ;
      JC    OBJ4;
      POP   ;
      L     2; //1 Object = 2 Analog-Value
      <>I   ;
      JC    OBJ1;
      JU    NOOB; //2 Objects in Tgrm
OBJ4: L     4;
      JU    NOOB; //4 Objects in Tgrm
OBJ1: L     1;
NOOB: T     #NoOfST1_Objects; //No of ST1-Obj., depending on Pack
      L     "BasicData".NofObjectItems2; //old number of objects in ref-list
      +I    ;
      T     "BasicData".NofObjectItems2; //new number of objects in ref-list
NETWORK
TITLE =
//Typical-Initialisation and basic settings.
M000: A     #OrgIndex_2_IN; //Object-DB is initialized ?
      JC    STRT;
      S     "BasicData".ObjRefListGen; //request for list generation
      A     #Enabled; //Typical is enabled ?
      S     #OrgIndex_2_FR; //set statusbit "Object is enabled"
      JC    PSET;
      S     #F3_S; //set "Object disabled" in Msg-header
      JU    PSET;
STRT: A     "BasicData".SystemStart; //System-Startup ?
      R     #OrgIndex_2_PF; //reset parameter error
      AN    "BasicData".SystemStart; //no System-Startup ?
      AN    #OrgIndex_2_PF; //no parameter error ?
      JC    M002;
      LAR1  P##OrgIndex_2_IN; //set pointer on INDEX_2 Word
      L     DIW [AR1,P#0.0]; //INDEX_2 in Akku 1
      L     2#1000011100000000; //mask on PF,..., SP, FR, IN
      AW    ;
      T     DIW [AR1,P#0.0]; //store INDEX_2
PSET: A     #TimeStamp; //Input: with Time-stamp ?
      =     #F3_Z; //set "with time-stamp" in Msg-header
      A     #Permanent; //Input: permanent transm. ?
      =     #F3_P; //set "permanent transm." in Msg-header
      L     P##MessageLen; //Pointer on first message byte
      SRW   3; //transform into Integervalue
      T     #SendMsgStartAddr; //preset Object-DB
      L     P##AnalogValue_1; //Pointer on Data Index 0
      SRW   3; //transform into Integervalue
      T     #AddrDataIndex_0; //preset Object-DB
      L     P##OrgIndex_0_Bit_8; //Pointer on Org Index 0
      SRW   3; //transform into Integervalue
      T     #AddrOrgIndex_0; //preset Object-DB
      AN    #OrgIndex_2_IN;
      S     #OrgIndex_2_IN; //set statusbit "Object is initialized"
      LAR1  P##F4_Bit_0; //set pointer on F4-Array
      L     0;
      T     DIB [AR1,P#0.0]; //preset F4-Array with 0
NETWORK
TITLE =
//Preset Object-DB if system startup.
      L     0;
      L     #PartnerNo; //Destination
      ==I   ;
      JC    NOPA; //no specified communication partner
      SLD   16;
      T     #SearchPartner; //preset data for FC_SEARCH
      TAR1  #Save_AR1; //save AR1
      TAR2  #Save_AR2; //save AR2
      CALL "Search" (
           NofObjects               := "BasicData".NofSubscrObjects,
           ObjectLength             := "BasicData".SubscrObjectLength,
           StartAddress             := "BasicData".StartSubscrObjList,
           CodeWanted               := #SearchPartner,
           CodeMask                 := DW#16#FFFF0000,
           RET_VAL                  := #SearchRetVal);
      LAR1  #Save_AR1; //restore AR1
      LAR2  #Save_AR2; //restore AR2
      L     0;
      L     #SearchRetVal; //result of "SEARCH"
      <=D   ;
      JC    ADOK; //no error in "SEARCH", address = ok
      L     W#16#B101; //Error-ID: PartnerNo not found in Subscr. List
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //unknown Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ERR1: L     W#16#B100; //Error-ID: PartnerNo not valid
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #PartnerNo; //incorrect Partner-No
      T     #DiagInfo_2;
      JU    PAFE;
ADOK: T     #SubsRecStartAddr; //start-addr. in subscr. database
      R     #OrgIndex_2_PF; //reset parameter error
      L     #PartnerNo; //Input: Destination-partner-no
      T     #DestSubscrNo; //dest.-Partner-No in Msg
      L     1;
      T     #ParamNumbOfPartners; //param.  number of Partners
      JU    OBJT;
NOPA: A     #ReverseDirection; //operation in reverse direction ?
      JC    ERR1; //Error: PartnerNo = 0 and rev. Dir.
      R     #OrgIndex_2_PF; //reset parameter error
      L     0;
      T     #SubsRecStartAddr; //start-addr. in subscr. database
      T     #DestSubscrNo; //dest.-Partner-No in Msg
      T     #DestObjectNo; //dest-Object-No in Msg
      T     #ParamNumbOfPartners; //param.  number of Partners
OBJT: AN    #ReverseDirection; //no operation in reverse direction ?
      S     "BasicData".ObjRefListGen; //request for list generation
      AN    #F3_Z; //no time-stamp in message ?
      JC    NO_T;
      L     0;
      T     #Time_Stamp_1; //delete 1. part of time-stamp
      T     #Time_Stamp_2; //delete 2. part of time-stamp
NO_T: L     0;
      T     #SendReqFlags; //clear send-req-mask
      T     #DataLostFlags; //clear data-lost-mask
      T     #LinkErrorFlags; //clear link-error-mask
      T     #NumbOfRecvdBytes; //delete number of recvd bytes
      LAR1  P##OrgIndex_0_Bit_8; //Pointer on Org-Index 0
      T     DIW [AR1,P#0.0]; //delete ORG_INDEX_0 flags
      LAR1  P##IntNewSendReq_Data; //Pointer on internal Send-flags
      T     DIW [AR1,P#0.0]; //delete internal NEW_ and OLD_SendReq-flags
NETWORK
TITLE =
//Preset ST1-Parameters.
      L     0;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >=I   ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     250; //max. value for ST1_Message_No
      >I    ;
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      L     0;
      <I    ;
      JC    EROB; //Error in Object No.
      >I    ;
      JC    AE1; //ST1-Message with AE = 1
      L     2;
      L     #ST1_MessageNo; //Message_No for ST1-Message
      >I    ; //Message_No < 2 and Obj.-No < 1 ?
      JC    ER10; //Error 10: ST1-Message_No not plausible !
      R     #F1_AE_1; //enter AE_ID = 0 into F1-Field
      R     #F1_AE_2; //    "          "          "
      L     0;
      T     #StartIndexNo; //preset Message
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE0R;
      T     #DestObjectNo; //preset Message
      L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
AE0R: L     #ST1_MessageNo; //Message_No for ST1-Message
      T     #DestObjectNo; //preset Message;
      L     DINO; //local Object-No
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
AE1:  S     #F1_AE_1; //enter AE_ID = 1 into F1-Field
      R     #F1_AE_2; //    "          "          "
      L     255;
      L     #ST1_IndexNo; //read Input-parameter
      <I    ;
      JC    ERIN; //Error : Index_No > 255
      L     0;
      <I    ;
      JC    ERIN; //Error : Index_No < 0
      POP   ;
      SLW   1; //multiply with 2
      T     #StartIndexNo; //enter into Message-area
      L     #AddrDataIndex_0; //Start-Addr. DataIndex-0
      TAK   ;
      -I    ;
      T     #AddrDataIndex_0; //corrected Start-Addr. DataIndex-0
      SET   ; //******** ENTER PACK VALUE ********
      R     #F2_PACK_1; //clear Pack-Bit 1
      R     #F2_PACK_2; //clear Pack-Bit 2
      R     #F2_PACK_3; //clear Pack-Bit 3
      L     0; //Defaultvalue: 1 Obj. = 4 Analogvalues
      L     #ST1_PACK_Value; //Input-Parameter
      ==I   ;
      S     #F2_PACK_1; //set Pack-Bit 1
      S     #F2_PACK_2; //set Pack-Bit 2
      S     #F2_PACK_3; //set Pack-Bit 3
      JC    PKOK;
      L     1; //1 Object = 1 Analogvalue
      ==I   ;
      S     #F2_PACK_2; //set Pack-Bit 2
      JC    PKOK;
      POP   ; //ST1_PACK_Value into Akku 1
      L     2; //1 Object = 2 Analogvalues
      ==I   ;
      S     #F2_PACK_1; //set Pack-Bit 1
      S     #F2_PACK_2; //set Pack-Bit 2
      JC    PKOK;
      POP   ; //ST1_PACK_Value into Akku 1
      L     4; //1 Object = 4 Analogvalues
      <>I   ;
      JC    ER12; //Error 12: Pack-Value not allowed
      S     #F2_PACK_3; //set Pack-Bit 3
PKOK: L     255;
      L     #ST1_ObjectNo; //Object_No for ST1-Message
      <I    ;
      JC    EROB; //Error: Object-No > 255
      L     #ST1_MessageNo; //Message_No for ST1-Message
      SLW   8; //Shift Message_No into High_Byte
      OW    ;
      A     #ReverseDirection; //Transmission in reverse direction ?
      JC    AE1R;
      T     #ST1MsgObjNo; //enter into Message-area
      L     0;
      T     #DestObjectNo;
      JU    M002;
AE1R: T     #DestObjectNo; //preset Message
      L     DINO; //local Object-No
      T     #ST1MsgObjNo; //preset Message
      JU    M002;
ER10: L     W#16#B103; //Error-ID: ST1_Message_No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_MessageNo; //incorrect ST1-Message-No
      T     #DiagInfo_2;
      JU    PAFE;
EROB: L     W#16#B104; //Error-ID: Object-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_ObjectNo; //incorrect ST1-Object-No
      T     #DiagInfo_2;
      JU    PAFE;
ERIN: L     W#16#B105; //Error-ID: Index-No not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_IndexNo; //incorrect ST1-Index-No
      T     #DiagInfo_2;
      JU    PAFE;
ER12: L     W#16#B106; //Error-ID: PACK-Value not plausible
      T     #DiagID;
      L     DINO; //current Object-No
      T     #DiagInfo_1;
      L     #ST1_PACK_Value; //incorrect Pack-Value
      T     #DiagInfo_2;
      JU    PAFE;
NETWORK
TITLE =
//Entry in Object-Reference-List required ?
M002: ON    "BasicData".ObjRefListEntry; //enter item in ref-list ?
      O     #ReverseDirection; //reverse transmission mode ?
      JC    NXNW;
      L     "BasicData".DB_ObjectList2; //DB-No. Subscriber List 2
      T     #DBObjRefList; //store temporarily
      L     0;
      T     #ActValue; //temporary Object-Counter
      L     #NoOfST1_Objects; //1, 2 or 4 Objects in Tgrm
LOPL: T     #TempInt; //temporary loopcounter
      L     "BasicData".OwnSubscrNo; //local subscriber no
      OPN   DB [#DBObjRefList]; //open DB ObjRefList1
      L     DBW    0; //address of next free block
      SLD   3; //convert INT into pointer
      LAR1  ; //preset address-reg. 1
      POP   ; //transfer subscrNo into akku 1
      T     DBW [AR1,P#0.0]; //store in Ref.List
      L     #ST1MsgObjNo; //local input parameter
      L     #ActValue; //temporary Object-counter, old
      +I    ;
      T     DBW [AR1,P#2.0]; //store in Ref.List
      L     DINO; //local object No
      T     DBW [AR1,P#4.0]; //store in Ref.List
      L     DBW    0; //old address of next free block
      +     6; //add offset on next free block
      T     DBW    0; //new address of next free block
      L     #ActValue; //temporary Object-counter, old
      +     1;
      T     #ActValue; //temporary Object-Counter, new
      L     #TempInt; //temporary loopcounter
      LOOP  LOPL;
NETWORK
TITLE =
//Enable / disable Typical-Operation
NXNW: AN    #Enabled; //Typical is not enabled ?
      JC    DISA;
      O     #OrgIndex_2_FR; //Typical is already enabled ?
      O     #OrgIndex_2_SP; //Typical was disabled by ORG_Command ?
      JC    NXT1;
      S     #OrgIndex_2_FR; //set status "enabled"
      S    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